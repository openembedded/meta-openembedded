inherit pypi setuptools
require python-jinja2.inc

RDEPENDS_${PN} += "${PYTHON_PN}-re"
