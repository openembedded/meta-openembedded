SUMMARY = "Docutils is a modular system for processing documentation into useful formats"
HOMEPAGE = "https://pypi.org/project/docutils/"
SECTION = "devel/python"
LICENSE = "BSD-2-Clause & GPL-2.0 & Python-2.0"
LIC_FILES_CHKSUM = "file://COPYING.txt;md5=836a1950177996968a49ff477a4a61c4"

SRC_URI[sha256sum] = "686577d2e4c32380bb50cbb22f575ed742d58168cee37e99117a854bcd88f125"

inherit pypi setuptools3
