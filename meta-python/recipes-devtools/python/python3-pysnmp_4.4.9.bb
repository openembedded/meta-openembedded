inherit distutils3
require python-pysnmp.inc
