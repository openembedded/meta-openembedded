inherit pypi setuptools3
require python-pymisp.inc

PNBLACKLIST[python3-pymisp] ?= "Runtime depends on blacklisted python3-pymisp"

PNBLACKLIST[python3-pymisp] ?= "Runtime depends on blacklisted python3-pymisp-dev"
