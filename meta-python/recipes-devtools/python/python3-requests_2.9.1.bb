inherit pypi3
require python-requests.inc
