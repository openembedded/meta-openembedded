inherit setuptools3
require python-protobuf.inc
CLEANBROKEN = "1"
