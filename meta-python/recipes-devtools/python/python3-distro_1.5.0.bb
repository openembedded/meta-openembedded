require python-distro.inc
inherit pypi setuptools3
