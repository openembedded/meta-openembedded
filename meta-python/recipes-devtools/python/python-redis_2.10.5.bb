inherit pypi
require python-redis.inc
