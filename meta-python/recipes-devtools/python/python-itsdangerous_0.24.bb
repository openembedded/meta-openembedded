inherit pypi
require python-itsdangerous.inc
