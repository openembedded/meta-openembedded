SUMMARY = "The Google API Client for Python is a client library for accessing the Plus, \
Moderator, and many other Google APIs."
HOMEPAGE = "https://github.com/googleapis/google-api-python-client"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=94023d14f6b58272fd885e4e3f2f08b3"

SRC_URI[sha256sum] = "72f69e67238e38b0da41b5a2e352dc39b4b5891d88f3db082aae7775da8fe58b"

inherit pypi setuptools3
