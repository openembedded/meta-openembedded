require python-pyflame.inc

SRC_URI += "file://0001-ptrace-Abstract-over-user_regs_struct-name-which-dif.patch"
