inherit pypi setuptools
require python-twisted.inc

RDEPENDS_${PN}-core = "python-core python-zopeinterface python-contextlib"
