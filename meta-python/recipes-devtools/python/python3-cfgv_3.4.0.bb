SUMMARY = "Validate configuration and produce human readable error messages."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=92844452d544a48a78abc3a862fbd8a4"

PYPI_PACKAGE = "cfgv"

inherit pypi setuptools3
SRC_URI[sha256sum] = "e52591d4c5f5dead8e0f673fb16db7949d2cfb3f7da4582893288f0ded8fe560"
