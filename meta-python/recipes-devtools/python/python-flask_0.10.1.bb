inherit pypi
require python-flask.inc
