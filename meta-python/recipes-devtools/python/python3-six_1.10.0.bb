inherit pypi3
require python-six.inc
