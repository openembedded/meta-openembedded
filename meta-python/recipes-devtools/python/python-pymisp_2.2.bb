inherit setuptools
require python-pymisp.inc
