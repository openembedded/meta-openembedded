inherit pypi
require python-werkzeug.inc
