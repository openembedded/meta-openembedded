inherit pypi setuptools3
require python-robotframework-seriallibrary.inc
