inherit pypi
require python-whoosh.inc
