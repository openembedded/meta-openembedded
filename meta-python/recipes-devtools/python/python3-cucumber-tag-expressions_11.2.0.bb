SUMMARY = "Cucumber tag expression parser"
DESCRIPTION = "Provides a tag-expression parser and evaluation logic for cucumber/behave"
HOMEPAGE = "https://github.com/cucumber/tag-expressions"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=134f1026f0de92fd30e71976590a2868"

SRC_URI[sha256sum] = "7de37ff754acd8a09a62ce37183ba235d7d1bcbfde17ea1bdbb2de517b689273"

inherit pypi python_uv_build
