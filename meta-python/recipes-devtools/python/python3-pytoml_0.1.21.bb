inherit pypi setuptools3
require python-pytoml.inc
