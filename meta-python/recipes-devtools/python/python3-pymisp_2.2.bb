inherit setuptools3
require python-pymisp.inc
