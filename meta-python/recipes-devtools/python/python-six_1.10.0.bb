inherit pypi
require python-six.inc
