SUMMARY = "Library with cross-python path, ini-parsing, io, code, log facilities"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a6bb0320b04a0a503f12f69fea479de9"

SRC_URI[md5sum] = "30c3fd92a53f1a5ed6f3591c1fe75c0e"
SRC_URI[sha256sum] = "28dd0b90d29b386afb552efc4e355c889f4639ce93658a7872a2150ece28bb89"

inherit pypi
