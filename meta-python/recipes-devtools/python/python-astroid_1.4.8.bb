SUMMARY = "An abstract syntax tree for Python with inference support."
HOMEPAGE = "https://pypi.python.org/pypi/astroid/1.4.8"
SECTION = "devel/python"
LICENSE = "LGPL"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

SRC_URI[md5sum] = "3def6c80afcd38b4ca4aca6aea71cbde"
SRC_URI[sha256sum] = "5f064785a7e45ed519285f2eb30b795e58a4932a0736b32030da6fef3394ddb3" 

inherit setuptools pypi
