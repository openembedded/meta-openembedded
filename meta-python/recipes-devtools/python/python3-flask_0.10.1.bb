inherit pypi3
require python-flask.inc
