SUMMARY = "OpenTelemetry Python SDK"
DESCRIPTION = "Python SDK for OpenTelemetry, an open source \
observability framework for cloud native software."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

SRC_URI[sha256sum] = "63d24a6ca645019a631e6a51999c73e93adcac1196ca640b8ae78a7cc4762bf3"

inherit pypi python_hatchling
