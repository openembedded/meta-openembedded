inherit pypi
require python-pymongo.inc
