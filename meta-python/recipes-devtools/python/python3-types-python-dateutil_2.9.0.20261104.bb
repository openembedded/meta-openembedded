SUMMARY = "Typing stubs for python-dateutil"
HOMEPAGE = "https://github.com/python/typeshed"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=6;endline=6;md5=320eb2c24b8d2e890b6800000ce9352c"

SRC_URI[sha256sum] = "5d0495702a5f7343741f5d842c531bcd1c941da8b4a85307d52ef43ba80252db"

inherit pypi python_setuptools_build_meta

