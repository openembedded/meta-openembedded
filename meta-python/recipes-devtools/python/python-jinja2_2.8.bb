inherit pypi
require python-jinja2.inc
