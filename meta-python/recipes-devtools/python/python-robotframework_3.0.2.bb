inherit setuptools
require python-robotframework.inc
