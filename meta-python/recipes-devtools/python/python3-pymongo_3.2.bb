inherit pypi3
require python-pymongo.inc
