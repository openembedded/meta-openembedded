inherit setuptools3
require python-cassandra-driver.inc
