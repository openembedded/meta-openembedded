inherit pypi3
require python-jinja2.inc
