SUMMARY = "OpenTelemetry Python API"
DESCRIPTION = "Python API for OpenTelemetry, an open source \
observability framework for cloud native software."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

SRC_URI[sha256sum] = "aa38ed19bcc084ba42782a73255b3582283eced7ad6dddbd6695189e69adfb75"

inherit pypi python_hatchling
