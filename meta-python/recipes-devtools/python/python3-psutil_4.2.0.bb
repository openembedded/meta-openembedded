inherit pypi setuptools3
require python-psutil.inc

RDEPENDS_${PN} += " \
    python3-subprocess \
"
