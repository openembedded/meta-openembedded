inherit pypi3
require python-redis.inc
