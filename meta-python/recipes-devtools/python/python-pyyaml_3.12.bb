inherit setuptools
require python-pyyaml.inc
