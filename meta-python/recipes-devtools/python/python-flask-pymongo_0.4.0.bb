inherit pypi
require python-flask-pymongo.inc
