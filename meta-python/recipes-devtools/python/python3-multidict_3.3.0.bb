SUMMARY = "Multidicts are useful for working with HTTP headers, URL query args etc."
HOMEPAGE = "https://github.com/aio-libs/multidict/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e74c98abe0de8f798ca609137f9cef4a"

inherit pypi setuptools3

SRC_URI[md5sum] = "7ecd7c2807fd76ba7ca83e4e0c7fdf5f"
SRC_URI[sha256sum] = "e76909da2fad6966281d4e0e4ccfd3c3025699ebcc30806afa09fa1384c3532b"
