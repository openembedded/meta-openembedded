inherit pypi3
require python-xlrd.inc
