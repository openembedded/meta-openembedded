inherit setuptools3
require python-pylint.inc
