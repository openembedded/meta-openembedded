inherit pypi3
require python-flask-pymongo.inc
