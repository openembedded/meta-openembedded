inherit pypi
require python-flask-login.inc
