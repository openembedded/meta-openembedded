inherit pypi setuptools3
require python-urllib3.inc

SRC_URI += "file://CVE-2020-7212.patch"
