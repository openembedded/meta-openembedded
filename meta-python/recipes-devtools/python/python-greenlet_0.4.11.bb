SUMMARY = "Python lightweight in-process concurrent programming"
LICENSE = "MIT & PSF"
LIC_FILES_CHKSUM = "file://LICENSE;md5=03143d7a1a9f5d8a0fee825f24ca9c36 \
                    file://LICENSE.PSF;md5=c106931d9429eda0492617f037b8f69a"

SRC_URI[md5sum] = "774808f543e130621700863bc20a21fe"
SRC_URI[sha256sum] = "e46510543912135b2663c2fc4e2867497579466d82184710b84fb718b31cc95d"

PYPI_PACKAGE_EXT = "zip"
inherit pypi distutils

