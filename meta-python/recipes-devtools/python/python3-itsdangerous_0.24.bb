inherit pypi3
require python-itsdangerous.inc
