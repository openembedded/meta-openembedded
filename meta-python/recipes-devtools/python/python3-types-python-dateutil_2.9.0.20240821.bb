SUMMARY = "Typing stubs for python-dateutil"
HOMEPAGE = "https://github.com/python/typeshed"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=6;endline=6;md5=c2d9643b4523fdf462545aeb1356ad23"

SRC_URI[sha256sum] = "9649d1dcb6fef1046fb18bebe9ea2aa0028b160918518c34589a46045f6ebd98"

inherit pypi setuptools3
