inherit pypi
require python-passlib.inc