inherit pypi3
require python-whoosh.inc
