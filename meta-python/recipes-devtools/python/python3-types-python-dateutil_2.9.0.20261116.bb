SUMMARY = "Typing stubs for python-dateutil"
HOMEPAGE = "https://github.com/python/typeshed"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=6;endline=6;md5=320eb2c24b8d2e890b6800000ce9352c"

SRC_URI[sha256sum] = "4213748a3f699431a83edf71969de9caa79d0846a5e8785c8a49072ff1968613"

inherit pypi python_setuptools_build_meta

