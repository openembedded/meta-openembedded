inherit pypi
require python-xlrd.inc
