inherit pypi-common setuptools3
