../../meta-oe/classes/gitpkgv.bbclass
