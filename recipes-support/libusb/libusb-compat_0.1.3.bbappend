PROVIDES = "virtual/libusb0"

inherit lib_package

