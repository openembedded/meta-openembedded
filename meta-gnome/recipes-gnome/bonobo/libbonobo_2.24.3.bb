require libbonobo.inc
PR = "r2"

SRC_URI += "file://0001-Remove-use-of-G_DISABLE_DEPRECATED.patch"
SRC_URI[archive.md5sum] = "b217cef6a187505290c66c5bf8225d38"
SRC_URI[archive.sha256sum] = "5310957fa90691689c0557218b8833f681666cae160bd84e1f2c2705189a4ebe"
