BBCLASSEXTEND = "native"
RRECOMMENDS_${PN}_virtclass-native = ""
EXTRA_OECONF_virtclass-native += "--disable-introspection"
