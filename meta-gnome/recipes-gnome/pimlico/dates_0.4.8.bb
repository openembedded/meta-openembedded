require dates.inc

PR = "r6"

SRC_URI = "http://pimlico-project.org/sources/dates/dates-${PV}.tar.gz"
