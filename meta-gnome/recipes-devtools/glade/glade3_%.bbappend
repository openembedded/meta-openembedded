PACKAGECONFIG ??= "gnome"
PNBLACKLIST[glade3] ?= "Depends on broken libgnomeui"
