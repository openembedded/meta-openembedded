inherit nativesdk
include projucer.inc
