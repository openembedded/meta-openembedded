require gssdp.inc

SRC_URI = "http://download.gnome.org/sources/${BPN}/0.12/${BPN}-${PV}.tar.xz"
SRC_URI[md5sum] = "8ac3a544ef0dcf8caaf7c249d2a50dc2"
SRC_URI[sha256sum] = "928aa257815d044fdbfc740f5799530d41897947b5d7854173f636b36d728414"
