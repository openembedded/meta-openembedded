require pango.inc

SRC_URI[archive.md5sum] = "caa74baea47e7e16bc73c89f9089d522"
SRC_URI[archive.sha256sum] = "5e278bc9430cc7bb00270f183360d262c5006b51248e8b537ea904573f200632"

PR = "${INC_PR}.0"

