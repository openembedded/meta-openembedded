SUMMARY = "Easy to use task manager"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"

inherit xfce-app

DEPENDS = "gtk+ cairo libwnck xfce4-dev-tools-native exo-native"

SRC_URI[md5sum] = "b8a707b25e32c1a296eb50d609aa49b8"
SRC_URI[sha256sum] = "f5aa2796dd9971f8ae400238bfcdd9fa1322dba1466d1e6fd5bf8ee7e88bee86"
