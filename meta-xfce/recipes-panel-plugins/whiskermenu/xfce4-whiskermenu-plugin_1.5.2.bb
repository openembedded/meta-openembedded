SUMMARY = "An alternate menu for the Xfce desktop environment"
HOMEPAGE = "http://gottcode.org/xfce4-whiskermenu-plugin/"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

inherit xfce-panel-plugin cmake

SRC_URI[md5sum] = "15187645e8be2c0d300714ce55c1a8d4"
SRC_URI[sha256sum] = "307cbfa532a28c5c753409aba0330c2da010047b8fc2d669e06f12bf17712e38"
