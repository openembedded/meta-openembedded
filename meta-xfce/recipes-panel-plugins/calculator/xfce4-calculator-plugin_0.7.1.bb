SUMMARY = "A calculator plugin for the Xfce panel"
HOMEPAGE = "https://docs.xfce.org/panel-plugins/xfce4-calculator-plugin/start"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=909430f63fddd63f120ba29e8979f65c"

inherit xfce-panel-plugin gtk-icon-cache

SRC_URI[sha256sum] = "e4016a03c3ef4ebddd97e4135f5e304f80677033c98e19644b9989ec6f5ada81"
