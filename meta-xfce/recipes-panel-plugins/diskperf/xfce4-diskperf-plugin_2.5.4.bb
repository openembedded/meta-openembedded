SUMMARY = "Panel plugin displaying instant disk/partition performance"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-diskperf-plugin"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=d3e627798d6a60bece47aa8b3532e1f1"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "2db453fc3ea2e4fe073ec313a25b0961"
SRC_URI[sha256sum] = "aab6b9c4e2f78620920efac6874c4edf426f05b63b94cfda0da8c99a91110a0b"
