DESCRIPTION = "Panel plugin displaying instant disk/partition performance"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-diskperf-plugin"
LICENSE = "RogerSeguin"
LIC_FILES_CHKSUM = "file://COPYING;md5=d3e627798d6a60bece47aa8b3532e1f1"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "ba880f763e273787d0c8365eebc4feab"
SRC_URI[sha256sum] = "418a250fe8d48f1fd87658206a8e6762032d35dc1b2e98e27d309a35f873f9b6"
