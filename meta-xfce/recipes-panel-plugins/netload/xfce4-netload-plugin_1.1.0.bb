DESCRIPTION = "Panel plugin displaying current load of the network interfaces"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-netload-plugin"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=35a7203c41b86d15546dddc05995f97f"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "19bee8171e7d681cb79539417f0b5917"
SRC_URI[sha256sum] = "8a33dfed24a7bbd8eaf333524f94eb24e7d3a14ffccb181e5cab1d1b05ae3bf7"
