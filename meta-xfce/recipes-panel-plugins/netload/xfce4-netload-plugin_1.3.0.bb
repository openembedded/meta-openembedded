SUMMARY = "Panel plugin displaying current load of the network interfaces"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-netload-plugin"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=35a7203c41b86d15546dddc05995f97f"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "9b625d8ad513085f2e1569171db00b44"
SRC_URI[sha256sum] = "615a280a1bc6c1e3f40755798217a230fd022f7744b095e7df978b63f25c8057"
