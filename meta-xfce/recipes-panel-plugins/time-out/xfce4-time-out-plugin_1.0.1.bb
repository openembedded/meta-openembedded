SUMMARY = "This plugin makes it possible to take periodical breaks"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-time-out-plugin"
SECTION = "x11/application"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=59530bdf33659b29e73d4adb9f9f6552"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "b6e4a3145d31c341e2506fb17b014587"
SRC_URI[sha256sum] = "e342f73315fa8176ac4fc321680a3959aa2e06fafed1ac78031fae64713a3db8"
