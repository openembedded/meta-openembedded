DESCRIPTION = "Panel plugin displaying menu with quick access to folders, documents, and removable media"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-places-plugin"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b6952d9a47fc2ad0f315510e1290455f"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "d075fffccf44bcf09a1bfcd4e0cd38a2"
SRC_URI[sha256sum] = "0266e6bb9905b6af25f80cbb364d2710b6b95100382d2d540edf9f8408e09936"
