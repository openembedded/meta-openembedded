SUMMARY = "Panel plugin displaying stats from a wireless lan interface"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-wavelan-plugin"
LICENSE = "BenediktMeurer FlorianRivoal"
LIC_FILES_CHKSUM = "file://COPYING;md5=e1e5872df9c5cf1a23f16493d9104920"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "50514bb286f1ed6761a1b36832bb7fe3"
SRC_URI[sha256sum] = "fe06c7ffc29c2d4ca7bc452b3356825354e276565de9b0a2d087ab55471755ae"
