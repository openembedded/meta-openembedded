DESCRIPTION = "Panel plugin displaying stats from a wireless lan interface"
HOMEPAGE = "http://goodies.xfce.org/projects/panel-plugins/xfce4-wavelan-plugin"
LICENSE = "BenediktMeurer FlorianRivoal"
LIC_FILES_CHKSUM = "file://COPYING;md5=e1e5872df9c5cf1a23f16493d9104920"

inherit xfce-panel-plugin

SRC_URI[md5sum] = "a4cd20ef471123936e762a139f1025e1"
SRC_URI[sha256sum] = "c5b2535b9c90d3fbf6a5f94d096fbc9cb5ce85e2c5d67df933f6fe74ae6f761d"
