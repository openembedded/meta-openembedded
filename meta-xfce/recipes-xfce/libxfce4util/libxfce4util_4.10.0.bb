DESCRIPTION = "Basic utility library for Xfce4"
SECTION = "x11/libs"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=252890d9eee26aab7b432e8b8a616475"
DEPENDS = "intltool-native xfce4-dev-tools-native glib-2.0"

inherit xfce

SRC_URI[md5sum] = "2e8defcd40cbf6afedde531b27314511"
SRC_URI[sha256sum] = "0979fee12880bb5f011ab38d6c7cc9afe5fd68eb96ccda895cb56dbc16e7608e"
