do_configure_prepend() {
       NOCONFIGURE=yes ./autogen.sh
}

AUTOTOOLS_COPYACLOCAL = "1"
