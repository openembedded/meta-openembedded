include compat-wireless.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "f02849a795137438238b4d166609eacc"
SRC_URI[sha256sum] = "9bbbc72bf0adf73012f377caa38147e90f6d77ef0369b52f9a687bc66bbfbcfa"
