require kpatch.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRCREV = "fd8209aa00525f3e6092eaccbc34f7ce13c4ebc9"

PV = "0.9.0"

S = "${WORKDIR}/git"

BBCLASSEXTEND = "native nativesdk"
