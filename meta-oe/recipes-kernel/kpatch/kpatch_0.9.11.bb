require kpatch.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRCREV = "bea635fbbeb11c5f0f5c0d4ffce34c2e9d2e8a6a"

BBCLASSEXTEND = "native nativesdk"
