require zsh.inc
DEPENDS = "ncurses libcap libpcre gdbm groff-native"

SRC_URI[md5sum] = "01df38e4aa34aa227462fdf2f6d4c5cd"
SRC_URI[sha256sum] = "835194ea83abd812b5fdb1d2bfa6427c4c4e95e771c4a75e9006037af8efd264"
