require zsh.inc
DEPENDS += "libcap libpcre gdbm groff-native"

SRC_URI[md5sum] = "6fb0e3e52a0f8de5ca63138391b81ce0"
SRC_URI[sha256sum] = "b35cf19e4a6ba39fd03c6372b8a8760a491cc2e2e4aba3d15023ff291c2894b4"
