require dialog.inc

LDFLAGS += "-static"

SRC_URI[md5sum] = "2e538305977178eb085a9859511c299d"
SRC_URI[sha256sum] = "305aa1000680aa87bb2148a725f9107ef4cd29dcd6185b44d079cb87cf0ce2f5"
