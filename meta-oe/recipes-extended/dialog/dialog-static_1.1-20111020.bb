require dialog.inc
PR = "${INC_PR}.0"

LDFLAGS += "-static"

SRC_URI[md5sum] = "15dd2ce9f537c0400f600d1a383aa0a3"
SRC_URI[sha256sum] = "746bf18b8414985864835b61536cee826ac916e6827fbcad9faffb496cae8a7a"
