require rsyslog.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "37562d0e71a24938a9ed7f242bd32d35"
SRC_URI[sha256sum] = "e034b02473fd7e5313522173ec2f6c57e6fbcaec2c6b289edb968b1d64ae3ffd"
