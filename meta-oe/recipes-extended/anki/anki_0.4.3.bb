require ${PN}-${PV}.inc

RDEPENDS_${PN} = "python-pyqt python-sip libanki"
RRECOMMENDS_${PN} = "virtual-japanese-font"
