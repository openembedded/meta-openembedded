require anki-${PV}.inc

S = "${WORKDIR}/anki-${PV}/libanki"
