require ${PN}_${PV}.inc

DEPENDS += "mysql5-native"

SRC_URI[md5sum] = "32e7373c16271606007374396e6742ad"
SRC_URI[sha256sum] = "2b0737b84e7b42c9e54c9658d23bfaee1189cd5955f26b10bdb862761d0f0432"
