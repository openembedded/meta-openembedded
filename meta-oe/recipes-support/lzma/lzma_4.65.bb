require lzma.inc
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "29d5ffd03a5a3e51aef6a74e9eafb759"
SRC_URI[sha256sum] = "c935fd04dd8e0e8c688a3078f3675d699679a90be81c12686837e0880aa0fa1e"
