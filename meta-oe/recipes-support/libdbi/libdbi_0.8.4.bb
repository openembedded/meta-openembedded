require ${PN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c5f15407ef7b07ba854cd8c9b15b88ff"
SRC_URI[sha256sum] = "ef38db616f0752ccb09b8ba2eac471722369b8ded50b153c25e238cac2c8de99"
