require asio.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=b99840878263c0bfaa70ca7143624413"

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "1879b246f9217d64bd3126aa16488bc2"
SRC_URI[sha256sum] = "aeb5c997940e6afd399c62316f03f480557f2b721354adff065d230183ff2782"
