BBCLASSEXTEND = "native"

