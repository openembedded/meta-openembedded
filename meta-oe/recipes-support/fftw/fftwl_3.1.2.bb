require fftw.inc

EXTRA_OECONF = "--disable-fortran --enable-long-double --enable-shared"



SRC_URI[md5sum] = "08f2e21c9fd02f4be2bd53a62592afa4"
SRC_URI[sha256sum] = "e1b92e97fe27efcbd150212d0d287ac907bd2fef0af32e16284fef5d1c1c26bf"
