require libgpiod.inc

SRC_URI[md5sum] = "9c1966bea7dffd59bd099a8b2930e2ea"
SRC_URI[sha256sum] = "50c7862428ca90b58672e2475aea66d33a6fc86c6bab1928c0660f3aedf44a37"
