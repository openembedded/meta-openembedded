include nano.inc

SRC_URI[md5sum] = "31714360342f9baa344e2fa574c144db"
SRC_URI[sha256sum] = "c2deac31ba4d3fd27a42fafcc47ccf499296cc69a422bbecab63f2933ea85488"
