require tangogps.inc

SRC_URI[archive.md5sum] = "0f07ede94a21eb84f5e017fa88a1fc3d"
SRC_URI[archive.sha256sum] = "660fdf89ef3c379f2fc0c2a9d0c9d3bfa5345835786b72bf9f513ba9ec2c812a"
