require libgcrypt.inc

PR = "r0"
