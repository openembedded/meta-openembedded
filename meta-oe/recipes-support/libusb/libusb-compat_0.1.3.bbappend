PROVIDES += "virtual/libusb0"
PROVIDES_virtclass-native += "virtual/libusb0-native"
BBCLASSEXTEND = "native nativesdk"

inherit lib_package

