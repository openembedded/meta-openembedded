require lvm2.inc

SRC_URI[md5sum] = "2d24ba982c8a85e8c837210f087a6a51"
SRC_URI[sha256sum] = "0e6da28465752cc2db7e7e6fc7b012a0146a98d717ac5dea1c900d4bc32bedb1"
