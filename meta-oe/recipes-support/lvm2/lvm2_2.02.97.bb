require lvm2.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "d18bd01334309db1c422b9bf6b181057"
SRC_URI[sha256sum] = "edda82012e8a9e1f0b00ba5a331468d3e0201992be14c0dbea71bf564a51fc2b"
