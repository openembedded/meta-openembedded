require lvm2.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "91785ca438e5ce679dd3a386b183d552"
SRC_URI[sha256sum] = "e5c2b0d76e7b1df7630e211734eb09697d66ab879b17eb19545cb77272813eb7"

