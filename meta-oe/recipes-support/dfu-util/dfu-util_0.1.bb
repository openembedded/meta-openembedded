require dfu-util.inc

PR = "r1"

DEPENDS = "virtual/libusb0 usbpath"

BBCLASSEXTEND = "native"

SRC_URI[md5sum] = "454b931249d29e4a6c2a2ade17858490"
SRC_URI[sha256sum] = "a27cc667be9b158fecf0ed066698e30eca0c0b3cd7a85aad2058d47ffe16f0e1"
