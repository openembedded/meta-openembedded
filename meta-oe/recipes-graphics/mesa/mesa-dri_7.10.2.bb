require mesa-common.inc
require mesa-${PV}.inc
require mesa-dri.inc
PR = "${INC_PR}.0"
