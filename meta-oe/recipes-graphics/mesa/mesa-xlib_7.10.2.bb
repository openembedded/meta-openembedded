require mesa-common.inc
require mesa-${PV}.inc
require mesa-xlib.inc
PR = "${INC_PR}.0"
