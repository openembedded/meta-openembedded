require cairo.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=e73e999e0c72b5ac9012424fa157ad77"

SRC_URI = "http://cairographics.org/releases/cairo-${PV}.tar.gz;name=cairo \
"
SRC_URI[cairo.md5sum] = "f101a9e88b783337b20b2e26dfd26d5f"
SRC_URI[cairo.sha256sum] = "32018c7998358eebc2ad578ff8d8559d34fc80252095f110a572ed23d989fc41"


