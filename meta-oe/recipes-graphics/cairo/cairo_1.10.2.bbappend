BBCLASSEXTEND += "native"
PRINC := "${@int(PRINC) + 1}"
