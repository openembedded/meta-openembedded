require xorg-app-common.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=5feafdbe6dfe9e2bd32325be0cfc86f8"
DEPENDS += " libxkbfile"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "2f6df89201eb9a2cbfb905d6b82a191e"
SRC_URI[archive.sha256sum] = "999591bf1ba8ca2a7d480b2c01702396e6c349d499fb583c0de136ec00dbae39"
