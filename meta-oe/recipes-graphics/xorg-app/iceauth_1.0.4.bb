require recipes-graphics/xorg-app/xorg-app-common.inc
SUMMARY = "Tool for manipulating ICE protocol authorization records"
LIC_FILES_CHKSUM = "file://COPYING;md5=13f70acf3c27f5f834bbc954df775f8e"
DEPENDS += "libice"
PR = "r6"

SRC_URI[md5sum] = "bb2e4d2611047f7c5a1a82ec956a9de4"
SRC_URI[sha256sum] = "0ee6fd4554f0131b1ed526ee00b9cf643e7dc97eb70fb51448848ef2f349938d"
