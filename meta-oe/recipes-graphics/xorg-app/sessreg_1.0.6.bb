require xorg-app-common.inc

DESCRIPTION = "a simple program for managing utmp/wtmp entries"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=07e6423e8815e6b372cd45da76faacd0"

PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8c8fcda19f4cffe573d43ec9b8255f8e"
SRC_URI[archive.sha256sum] = "73f31670842b7d969504a61f3c694bf1911f844831c390396971ae2b74de7190"
