include xcb-proto.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "04313e1d914b44d0e457f6c494fc178b"
SRC_URI[sha256sum] = "f52bc1159b12496f002404eb5793c01277b20c82cb72c5ff076d7b25da9b5ca2"

