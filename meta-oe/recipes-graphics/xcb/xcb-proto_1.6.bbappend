BBCLASSEXTEND += "nativesdk"

