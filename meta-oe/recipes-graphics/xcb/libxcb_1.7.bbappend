BBCLASSEXTEND = "native nativesdk"

