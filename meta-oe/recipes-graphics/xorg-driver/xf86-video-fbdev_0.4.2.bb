require xorg-driver-video.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=d8cbd99fff773f92e844948f74ef0df8"

DESCRIPTION = "X.Org X server -- fbdev display driver"
PE = "1"
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "53a533d9e0c2da50962282526bace074"
SRC_URI[sha256sum] = "93b271b4b41d7e5ca108849a583b9523e96c51813d046282285355b7001f82d5"
