require recipes-graphics/xorg-driver/xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- void input driver"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=4be6a915bfbf111cd88706fc6a6f141b"

SRC_URI[md5sum] = "3056bc7c57db8c5d56039648c0530c45"
SRC_URI[sha256sum] = "aba69784ac83f5951af3e164312adb4b8b1c91a8f79ab35dc5165c534e14c674"
