require geos.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "5b7270c73fd1c516f368af8fd1962323"
SRC_URI[sha256sum] = "ec64d3a92540a1618aa3b91dc1235caae1c370ec23afd59a2734062bf182ed5b"

