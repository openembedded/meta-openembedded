require proj.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "927d34623b52e0209ba2bfcca18fe8cd"
SRC_URI[sha256sum] = "fc5440002a496532bfaf423c28bdfaf9e26cc96c84ccefcdefde911efbd98986"

