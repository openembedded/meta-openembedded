include cups-filters.inc

SRC_URI += "file://0001-use-noexcept-false-instead-of-throw-from-c-17-onward.patch"
SRC_URI[sha256sum] = "472418f1a1e12c9ad91b01caa020eb668626776d85de9da488be38e6663102ca"
