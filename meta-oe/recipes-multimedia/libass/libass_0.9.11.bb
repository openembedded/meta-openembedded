require ${PN}.inc
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

SRC_URI[md5sum] = "f9042884397002ba40aa89dc7d34f59f"
SRC_URI[sha256sum] = "ffd0a7ccf635c4795edb8f61015b47ff84ec9c5babf502dd2cc8223d4489745c"
