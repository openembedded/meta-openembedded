require live555.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504 \
                    file://COPYING.LESSER;md5=e6a600fd5e1d9cbde2d983680233ad02 \
                   "

SRC_URI[md5sum] = "71e096f7b3055a141fb902d7ea45ef61"
SRC_URI[sha256sum] = "7653c44ac1c8255dd34d9151a92db8ef4af224e8b980e4af2f8937b3a30d38af"
