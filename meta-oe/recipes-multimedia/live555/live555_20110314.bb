require live555.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=68ad62c64cc6c620126241fd429e68fe"

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ff65b2c598e970b4b6c8219a1811de00"
SRC_URI[sha256sum] = "c6ce050a7f9f69901e6f7f81a6745c82d9419e3904a753b2d5db1139caaf6738"


