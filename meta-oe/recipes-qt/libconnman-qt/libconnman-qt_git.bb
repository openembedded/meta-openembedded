inherit qt4x11

require libconnman-qt.inc
