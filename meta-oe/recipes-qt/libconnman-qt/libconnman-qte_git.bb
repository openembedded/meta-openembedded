inherit qt4e

require libconnman-qt.inc
