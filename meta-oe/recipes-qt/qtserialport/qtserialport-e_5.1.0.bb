inherit qt4e

require qtserialport.inc

SRCREV = "22e45f0b0f956c025339d72ad53dca57ef684858"
