RDEPENDS_${PN} += "qwt-e-dev"

PRINC = "1"
