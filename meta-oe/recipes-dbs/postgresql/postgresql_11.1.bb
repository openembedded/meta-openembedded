require postgresql.inc

LIC_FILES_CHKSUM = "file://COPYRIGHT;md5=6dc95e63aa4d72502ff8193dfe2ddd38"

SRC_URI += "\
   file://not-check-libperl.patch \
"

SRC_URI[md5sum] = "5e45f6d5b859cc76b5d62f1e328e9711"
SRC_URI[sha256sum] = "90815e812874831e9a4bf6e1136bf73bc2c5a0464ef142e2dfea40cda206db08"
