require timescaledb.inc

BRANCH="2.5.x"
COMMIT="a2530ab5f251ba9680d2c270496d1e2e6fcf6367"
