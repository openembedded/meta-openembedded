require midori.inc

SRC_URI[midori.md5sum] = "a5821d8e31fa944374ed51c09ca4e740"
SRC_URI[midori.sha256sum] = "803bf534ab73cf7a50ddd38bbd68976258c36f335a3f1dc1880f53915c7fdf78"


