require uhd-firmware.inc

LIC_FILES_CHKSUM = "file://share/uhd/images/usrp_e100_fpga.bin;md5=38e997b0ea38503d7d7f389ba76d39df"

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "6db20f93e3c4646395bd6e8260e2261f"
SRC_URI[sha256sum] = "4c73655519cd9f4e49e5727f094b463850b03db13d91a8b0429b789e74a9deea"

