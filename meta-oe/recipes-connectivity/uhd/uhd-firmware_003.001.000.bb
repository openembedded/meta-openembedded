require uhd-firmware.inc
LIC_FILES_CHKSUM = "file://share/uhd/images/usrp_e100_fpga.bin;md5=f4e787828ebe5a886be67fe9fb71cc61"

PV = "003_001_000"
PVdots = "003.001.000"
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "0d6a6792c6b98e9163d67cb62bf29dce"
SRC_URI[sha256sum] = "3b25726946026c6d25061403e3343d72b34cc41e7e44026b272510379d01233a"

