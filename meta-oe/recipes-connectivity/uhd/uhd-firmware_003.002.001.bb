require uhd-firmware.inc
LIC_FILES_CHKSUM = "file://share/uhd/images/usrp_e100_fpga_v2.bin;md5=ea9a4b4421aeeca7c864fd8ca6dd73dd"

PV = "003_002_001"
PVdots = "003.002.001"
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "1894391da027884e5eed474606250be9"
SRC_URI[sha256sum] = "c194d9e30bb02225de623400bdba9be9200f70a57c6220506bc0b051eed8fae8"

