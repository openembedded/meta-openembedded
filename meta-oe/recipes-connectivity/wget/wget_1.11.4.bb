PR="${INC_PR}.0"

SRC_URI = "${GNU_MIRROR}/wget/wget-${PV}.tar.gz"
SRC_URI[md5sum] = "69e8a7296c0e12c53bd9ffd786462e87"
SRC_URI[sha256sum] = "7315963b6eefb7530b4a4f63a5d5ccdab30078784cf41ccb5297873f9adea2f3"

require wget.inc
