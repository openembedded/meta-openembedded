inherit gnomebase

GNOME_COMPRESS_TYPE="xz"

SRC_URI[archive.md5sum] = "a8b7c11db81a72168bf38d88d97df686"
SRC_URI[archive.sha256sum] = "78f47336f3bdf034a384c59a39cc9f0d566e69e36aa7c9ee3ec0bb6a94bf8b3e"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

BBCLASSEXTEND = "native"

