DEPENDS_virtclass-native = "cairo-native pango-native gdk-pixbuf-native"
BBCLASSEXTEND = "native"
