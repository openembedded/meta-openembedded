FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

RDEPENDS_packagegroup-meta-oe-support += "debsums"
