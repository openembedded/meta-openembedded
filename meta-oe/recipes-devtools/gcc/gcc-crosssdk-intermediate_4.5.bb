require recipes-devtools/gcc/gcc-cross-intermediate_${PV}.bb
require recipes-devtools/gcc/gcc-crosssdk-intermediate.inc

PR = "${INC_PR}.0"
