require python-sip.inc
SRC_URI[md5sum] = "76192829cc42ec558db46e4f9e1d8ba9"
SRC_URI[sha256sum] = "ec295f71ef339c5b98db5650865f2c6c1200c4085b7a3f33f284111e1f534ac1"
