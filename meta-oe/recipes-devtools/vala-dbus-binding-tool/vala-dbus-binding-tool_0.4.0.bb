require vala-dbus-binding-tool.inc

SRC_URI[archive.md5sum] = "b7537a087f9f468e25170e81df0ed93f"
SRC_URI[archive.sha256sum] = "6b0d3796e92b031839e2e2f484e294153ad9eaf9d32915056199a49ce8328722"
