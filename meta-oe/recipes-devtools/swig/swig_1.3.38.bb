require swig.inc

PR = "${INC_PR}.0"


SRC_URI[md5sum] = "650c774917be49c526a4f8a3e733c898"
SRC_URI[sha256sum] = "e7cbddc8c68b1eccba1c82edd5427595397d9a483c8fb1184abc9303afe08045"
