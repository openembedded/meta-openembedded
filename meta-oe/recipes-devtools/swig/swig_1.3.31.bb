require swig.inc

PR = "${INC_PR}.0"


SRC_URI[md5sum] = "4a0bae63e3713e89b26db7209b6a7e05"
SRC_URI[sha256sum] = "c2ad63095e34b4a474e7ff4adb6ea8b7ab238bb5738d00a739102bb8bb71d805"
