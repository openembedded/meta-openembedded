require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI += "file://0001-Use-proc-self-exe-for-swig-swiglib-on-non-Win32-plat.patch"

SRC_URI[md5sum] = "54d534b14a70badc226129159412ea85"
SRC_URI[sha256sum] = "586954000d297fafd7e91d1ad31089cc7e249f658889d11a44605d3662569539"
