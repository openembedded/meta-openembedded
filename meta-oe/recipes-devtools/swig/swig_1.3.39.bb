require swig.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ac201d1b87f8659584534f9540d7ad24"
SRC_URI[sha256sum] = "bb2d5d9373cf1fe03faaadb02de47af3b058b0300e0f58ece6a7212f0a2b11dc"
