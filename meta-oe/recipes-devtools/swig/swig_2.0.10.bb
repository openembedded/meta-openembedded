require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI += "file://0001-Use-proc-self-exe-for-swig-swiglib-on-non-Win32-plat.patch"

SRC_URI[md5sum] = "6d5e7ad05b4a404e5e85db9befb70c9a"
SRC_URI[sha256sum] = "d1eef329e867124ce60838b5ad07c763146b6c8f250dd22a861ead7406f78e63"

