require swig.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "36ee2d9974be46a9f0a36460af928eb9"
SRC_URI[sha256sum] = "2568d042d3c7cfbcb17e2471b0434bd3aa78d7a1829f9ef6f1b9fc522e4754ea"

