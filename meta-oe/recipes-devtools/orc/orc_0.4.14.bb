require orc.inc

PR = "${INC_PR}.0"

SRC_URI[orc.md5sum] = "6b3ff209e9763ebe40e152538884bd71"
SRC_URI[orc.sha256sum] = "6b0c536984871954364976516ea0328e2dcd856111726a23e609504ba2b12313"
