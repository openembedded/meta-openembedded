require orc.inc

PR = "${INC_PR}.0"

SRC_URI[orc.md5sum] = "1a2552e8d127526c48d644fe6437b377"
SRC_URI[orc.sha256sum] = "34d3c8a7259f42bed4dcfbc106c5e3d0cc8e17eeaa73128d1c5eaf92883a6a24"
