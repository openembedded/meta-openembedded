require orc.inc

PR = "${INC_PR}.0"

SRC_URI[orc.md5sum] = "e482932e544c847761449b106ecbc483"
SRC_URI[orc.sha256sum] = "700e4edba20a0ed42164b645da26ce515b883d4c4633b222302f1e541f2a58ab"
