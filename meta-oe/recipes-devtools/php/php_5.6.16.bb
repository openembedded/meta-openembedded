require php.inc

SRC_URI += "file://change-AC_TRY_RUN-to-AC_TRY_LINK.patch"
SRC_URI[md5sum] = "765b164b89af1f03ae2fdf39a4e4e1df"
SRC_URI[sha256sum] = "4fe6f40964c1bfaba05fc144ba20a2cdad33e11685f4f101ea5a48b98bbcd2ae"
