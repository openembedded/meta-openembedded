require php.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=b602636d46a61c0ac0432bbf5c078fe4"

SRC_URI += "file://change-AC_TRY_RUN-to-AC_TRY_LINK.patch"
SRC_URI[md5sum] = "147734b7e0164ebdd2dc18474fcfb309"
SRC_URI[sha256sum] = "facd280896d277e6f7084b60839e693d4db68318bfc92085d3dc0251fd3558c7"
