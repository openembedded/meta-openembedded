require php.inc

SRC_URI[md5sum] = "ebb66ad8e2bcf1a966b10d86e81a0119"
SRC_URI[sha256sum] = "fb4a382b9a9dceb749b7ef047d8251320bc8d371c843714e5b4f4b70d61ba277"
