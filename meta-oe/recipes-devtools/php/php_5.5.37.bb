require php.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=464ca70af214d2407f6b7d4458158afd"

SRC_URI[md5sum] = "3a4b249bee5451a0982263a94a8a8c9d"
SRC_URI[sha256sum] = "d2380ebe46caf17f2c4cd055867d00a82e6702dc5f62dc29ce864a5742905d88"
