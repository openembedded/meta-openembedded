require php.inc

SRC_URI[md5sum] = "383a4b35327809afd2822e1e5efc8ee1"
SRC_URI[sha256sum] = "816afffdb03ff4c542bc172a2f77f9c69b817df82d60cce05c1b4f578c2c926e"
