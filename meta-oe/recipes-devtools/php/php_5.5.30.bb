require php.inc

SRC_URI[md5sum] = "181d153c9fba7ff46534df1bdab4d853"
SRC_URI[sha256sum] = "e7332a713cecdd1cb44a1b1336739885c9789f633f0f51236b25e48ab03c3b29"
