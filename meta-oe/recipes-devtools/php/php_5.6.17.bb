require php.inc

SRC_URI += "file://change-AC_TRY_RUN-to-AC_TRY_LINK.patch"
SRC_URI[md5sum] = "23e2183852b172a8e2b2c739b7dde4ca"
SRC_URI[sha256sum] = "77b45f56a1e63e75bb22b42cfb8b438ec4083c59ce774b4d7c1685544b7add3b"
