require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=4f8e906e7514a0d414eec27d5ecb46ed"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-diff.git;protocol=https;branch=main;tag=v${PV}"
SRCREV = "ada384ac7bfc1307f32de474620120add29998fb"
