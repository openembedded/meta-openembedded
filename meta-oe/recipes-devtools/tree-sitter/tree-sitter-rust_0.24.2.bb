require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ac1623bd8a20876e47103c894fd8808a"

SRC_URI = "git://github.com/tree-sitter/tree-sitter-rust.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "77a3747266f4d621d0757825e6b11edcbf991ca5"
