require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fc925cbf1bb87ecaeedbcdc573fc7651"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-toml.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "64b56832c2cffe41758f28e05c756a3a98d16f41"
