require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=52adf5c4bb8fe6703ee211cd5415e4f6"

SRC_URI = "git://github.com/tree-sitter/tree-sitter-json.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "ee35a6ebefcef0c5c416c0d1ccec7370cfca5a24"
