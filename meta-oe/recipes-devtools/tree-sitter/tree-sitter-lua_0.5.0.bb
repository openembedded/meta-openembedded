require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=aab6641082436ddc4655e6b43dc9fe98"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-lua.git;protocol=https;branch=main;tag=v${PV}"
SRCREV = "10fe0054734eec83049514ea2e718b2a56acd0c9"
