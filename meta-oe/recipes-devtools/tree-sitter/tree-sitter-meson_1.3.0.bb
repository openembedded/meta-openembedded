require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2375704453b348c6c8b93af2d6f83ef8"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-meson.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "12edaf0dfef0a43bc74336a4432b2db1c65788d6"
