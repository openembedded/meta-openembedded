require tree-sitter-grammar.inc

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

SRC_URI = "git://github.com/neovim/tree-sitter-vimdoc.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "13add92d357b69646c080a8028b82ffb106faf7a"
