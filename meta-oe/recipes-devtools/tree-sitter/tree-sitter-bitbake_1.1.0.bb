require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7dcf1d5ba61a94226e43f0705d73c97d"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-bitbake.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "10bacac929ff36a1e8f4056503fe4f8717b21b94"
