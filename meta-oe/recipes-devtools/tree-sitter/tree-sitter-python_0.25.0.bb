require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c191fd97f3c9e58e623af9aa4cf2998c"

SRC_URI = "git://github.com/tree-sitter/tree-sitter-python.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "293fdc02038ee2bf0e2e206711b69c90ac0d413f"
