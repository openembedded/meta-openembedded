require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=46ca08e8c14dc63f12300d0de691980b"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-vim.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "3092fcd99eb87bbd0fc434aa03650ba58bd5b43b"
