require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=890ca54f377bbd88baa2280077889dae"

SRC_URI = "git://github.com/uyha/tree-sitter-cmake.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "a3ec2b2144daf7132e7ee824d8cab9610523d10f"
