require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1519ffdf2ebaba430e2c4f27f95ab17c"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-make.git;protocol=https;branch=main;tag=v${PV}"
SRCREV = "5e9e8f8ff3387b0edcaa90f46ddf3629f4cfeb1d"
