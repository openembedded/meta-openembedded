require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=92d9c25147972986a42a9bdc1886746c"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-yaml.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "7708026449bed86239b1cd5bce6e3c34dbca6415"
