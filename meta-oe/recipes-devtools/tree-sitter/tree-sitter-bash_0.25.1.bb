require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2220463fa5825d0a3935ade6f38bdd69"

SRC_URI = "git://github.com/tree-sitter/tree-sitter-bash.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "a06c2e4415e9bc0346c6b86d401879ffb44058f7"
