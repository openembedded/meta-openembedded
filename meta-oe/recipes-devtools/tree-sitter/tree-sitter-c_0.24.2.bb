require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=52adf5c4bb8fe6703ee211cd5415e4f6"

SRC_URI = "git://github.com/tree-sitter/tree-sitter-c.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "b780e47fc780ddc8da13afa35a3f4ed5c157823d"
