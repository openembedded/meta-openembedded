require tree-sitter-grammar.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=52adf5c4bb8fe6703ee211cd5415e4f6"

SRC_URI = "git://github.com/tree-sitter/tree-sitter-cpp.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "f41e1a044c8a84ea9fa8577fdd2eab92ec96de02"
