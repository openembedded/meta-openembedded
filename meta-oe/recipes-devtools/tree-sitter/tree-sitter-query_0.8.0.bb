require tree-sitter-grammar.inc

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327"

SRC_URI = "git://github.com/tree-sitter-grammars/tree-sitter-query.git;protocol=https;branch=master;tag=v${PV}"
SRCREV = "a225e21d81201be77da58de614e2b7851735677a"
