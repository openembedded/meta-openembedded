require ${BPN}.inc

PR = "${INC_PR}.1"

SRC_URI += " file://0001-git-version-gen-don-t-append-dirty-if-we-re-not-in-g.patch"

SRC_URI[md5sum] = "84b742e9cca4c90fde3026c3793c03c1"
SRC_URI[sha256sum] = "3adb37aa2b35e2e2daed47552e85dbcbf752c0f7768b269d856993620073a657"
