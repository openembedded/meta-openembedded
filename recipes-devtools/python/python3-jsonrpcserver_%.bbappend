FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI = "\
        file://0001-Use-importlib.resources-instead-of-pkg_resources.patch \
"
