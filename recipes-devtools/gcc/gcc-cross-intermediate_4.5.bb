require gcc-cross_${PV}.bb
require gcc-cross-intermediate.inc
PR = "${INC_PR}.0"

