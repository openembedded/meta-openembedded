require gcc-cross-intermediate_${PV}.bb
require gcc-crosssdk-intermediate.inc

PR = "${INC_PR}.0"
