require gcc-cross_${PV}.bb
require gcc-cross-initial.inc

PR = "${INC_PR}.0"

