require gcc-cross_${PV}.bb
require gcc-crosssdk.inc

PR = "${INC_PR}.0"
