require gcc-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc

PR = "${INC_PR}.0"
