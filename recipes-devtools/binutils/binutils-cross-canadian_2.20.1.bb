require binutils_${PV}.bb
require binutils-cross-canadian.inc
PR = "r6"
