# For tipcutils
PACKAGECONFIG_append = " tipc"
