require quagga.inc

SRC_URI[md5sum] = "e84be2938c26c0c872792090f1a6a866"
SRC_URI[sha256sum] = "522e22f2beee64e3f0c2cde3d0155f3b8103f4f6fc8abef92cb40bc3a4cc2931"
