require xl2tpd.inc
PR = "${INC_PR}.0"

SRCREV = "a96b345962622ea58490924130675df6db062d11"

