require dnsmasq.inc

SRC_URI[dnsmasq-2.63.md5sum] = "43e771997615ebcd8f6c6ffa60c3e40b"
SRC_URI[dnsmasq-2.63.sha256sum] = "fd86e3bcc6a63c76e35e4a20baa790e7bbbfc7b43845cae85ca8ffd024467710"
