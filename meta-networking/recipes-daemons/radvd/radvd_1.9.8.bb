PR = "r0"

require radvd.inc

SRC_URI[md5sum] = "7a96a38252c3964ee18bbc1fdeae25fa"
SRC_URI[sha256sum] = "645ccf1c9b16e769ff4179813712e580e2c8786d64a888d8afa1e296c057c1c1"
