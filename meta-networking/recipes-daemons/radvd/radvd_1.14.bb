
require radvd.inc

SRC_URI[md5sum] = "a257e05bd6a435ef948d3b407726d56f"
SRC_URI[sha256sum] = "3b16dd9ef3d6c8b889cdabfdb16c81db8bd61b0f1fc42f6acc52d3cf300c6d07"

