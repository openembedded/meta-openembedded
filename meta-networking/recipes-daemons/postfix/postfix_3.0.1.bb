require postfix.inc


SRC_URI[md5sum] = "3ec1416e7d4fba9566297c8fcf7a348c"
SRC_URI[sha256sum] = "cd2bd6447fe3368bb1a39f482f8dd1eec87c63067a0eb75f9aec8e4eadd21328"
