require postfix.inc

SRC_URI[md5sum] = "d1dc2c23011c222129db3d91aa4f312a"
SRC_URI[sha256sum] = "68256314202f5f0f24022d64f7ac664d28fa1394d07c84a37c3fc7a2d040be80"
