require postfix.inc

SRC_URI += "file://postfix-add-db6-support.patch"

SRC_URI[md5sum] = "56ac1f1a79737c4ac1e24535a122a4a6"
SRC_URI[sha256sum] = "487f98a73b95a5799409caf21ec065efea91c1dcdfb84c038a0e3a265d6489e2"
