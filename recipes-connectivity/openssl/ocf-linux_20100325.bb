require ocf-linux.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ce5ad54aa94226d496df1f0f3cf0c11f"
SRC_URI[sha256sum] = "9d17cbd13849939c70699b520280e3b94cf77401cdc131108d4aeaaeea587f6b"
