require ${BPN}.inc

SRC_URI[md5sum] = "090aa2b22447ea83a1aca9f284ce5288"
SRC_URI[sha256sum] = "bb9f30bf437b8e9ad5a4ba405795c1f8f840a37c660a6d47a2829587b32dbb67"
