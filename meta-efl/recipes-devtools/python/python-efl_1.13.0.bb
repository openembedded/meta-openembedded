require ${BPN}.inc

SRC_URI[md5sum] = "98b1ca3e0feeecf8b993f9c415ff22e5"
SRC_URI[sha256sum] = "16b8234ee763fab27071e7d708accbdb0cd43eecdfdb08775853bf380e558f8d"
