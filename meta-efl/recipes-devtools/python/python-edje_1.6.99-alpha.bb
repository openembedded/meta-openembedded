require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-alpha"
SRC_URI += "file://0001-fix-unicode-conversion.patch"

SRC_URI[md5sum] = "fbe5105abb5b2d3de71302ff3973945a"
SRC_URI[sha256sum] = "f5004d9b784b0ca37436daacff7f4f21bb3094b9fdfc5abc95f8e57e90ecb242"
