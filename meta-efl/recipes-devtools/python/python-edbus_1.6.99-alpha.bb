require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-alpha"

SRC_URI[md5sum] = "bd68e260e1a23fc14313afa48e70bebd"
SRC_URI[sha256sum] = "63e823c8366f293db1940524ac76d6f91109a7202cf38ad6407d414d15e09aca"
