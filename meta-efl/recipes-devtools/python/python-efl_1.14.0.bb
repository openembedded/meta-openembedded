require ${BPN}.inc

SRC_URI[md5sum] = "e90871bb1c9f647e763c480e74bbfcbd"
SRC_URI[sha256sum] = "0003151b224937d36ef78236398b9a3d6dd39a5692fb1ba4f9c900e65b2ddade"
