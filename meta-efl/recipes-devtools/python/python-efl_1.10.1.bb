require ${BPN}.inc

SRC_URI[md5sum] = "1cc68d6cd77d9d20d07c91188d523a9a"
SRC_URI[sha256sum] = "a6c803bdd205e08c2d1e3199abd095552bc7ca4be6faafaf3b3f6db1d78c80ef"
