require ${BPN}.inc
PR = "${INC_PR}.0"
SRC_URI += "file://0001-fix-unicode-conversion.patch"

SRC_URI[md5sum] = "1e0d7a4a4504298caaad0cee476e4edb"
SRC_URI[sha256sum] = "b1eb7be4dea099752c587baa4747d8100de6cead256ffea22a6cc0e88c4e8786"
