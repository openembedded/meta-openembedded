require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-alpha"

SRC_URI[md5sum] = "86ba753726881b9bfcaa0fdc0827cd1e"
SRC_URI[sha256sum] = "b47a155c0bfad6fad68bc0f925c54a8736a61ca72f6a71bd5138ea3298a35c95"
