require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-beta"
SRC_URI += "file://0001-fix-unicode-conversion.patch"

SRC_URI[md5sum] = "eac613c2f3d88d30ba1adf4acd5090bf"
SRC_URI[sha256sum] = "6ce7b57a4afaddf8dbf423543380cdc798c954b31ffd9d47e6af9536786abc05"
