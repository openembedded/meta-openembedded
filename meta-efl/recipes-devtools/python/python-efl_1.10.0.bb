require ${BPN}.inc

SRC_URI[md5sum] = "46166e51bdbab4f2fa790dee98b1ccf5"
SRC_URI[sha256sum] = "b144e976a351cd9703771b5e91a45ce9b2eedcc0097ade5c5437554b1516dbc6"
