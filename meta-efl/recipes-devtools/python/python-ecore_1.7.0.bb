require ${BPN}.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "15dd908b71d09ef30f7e758739f3b6fd"
SRC_URI[sha256sum] = "45d374ffab243b561718897e4eac9aadc1e7ce6e34321a3e728a5f6d07d1e9b6"
