require ${BPN}.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c3fda2025171f5e3d2bc224e8bae88e5"
SRC_URI[sha256sum] = "bc00ea23d4d3e9d6448c8a24f918f577cf3c2b25636f36b76b2ed2e3a74d42f5"
