require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-alpha"

SRC_URI[md5sum] = "34249ce9ee6602205ede16e311c2712c"
SRC_URI[sha256sum] = "f121a801c213d5014cde17df49107407bd60be362f98bab3530c14c9c8a54e03"
