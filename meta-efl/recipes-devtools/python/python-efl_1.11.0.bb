require ${BPN}.inc

SRC_URI[md5sum] = "b378f48ae4defbcb7c3e82479d106cfc"
SRC_URI[sha256sum] = "e147b5c8995afbae691b90385ec3b008f9675207c7aa3c3bb724c57d9bcf8ed5"
