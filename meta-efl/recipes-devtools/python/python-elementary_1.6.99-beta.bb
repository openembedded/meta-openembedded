require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-beta"

SRC_URI[md5sum] = "f2b801aa8fe53914abbcfdf14aa1d325"
SRC_URI[sha256sum] = "1255bab89b824754c1a0909f2646ff63fd0e12478e0bfbfbdc3cfd48ea9bfa25"
