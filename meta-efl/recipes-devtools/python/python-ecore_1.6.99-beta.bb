require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-beta"

SRC_URI[md5sum] = "7cd483e817e41017adcd23cea4ce462d"
SRC_URI[sha256sum] = "09a99f728b946c44955ad91e3ac072643e533ded74110f481e27b8f035877a95"
