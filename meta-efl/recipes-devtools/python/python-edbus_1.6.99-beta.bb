require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-beta"

SRC_URI[md5sum] = "d6140208bb2608bd320a70298c0c4234"
SRC_URI[sha256sum] = "468bc77dc1b64d04c688b2f07ddcbeac406d984121b90e78ba802c92e58e4daf"
