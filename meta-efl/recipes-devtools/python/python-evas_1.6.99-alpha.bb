require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-alpha"

SRC_URI[md5sum] = "c3e02d8e897508db2d6365dc3b83ae20"
SRC_URI[sha256sum] = "5af43a770e0edaf01c679c8eaecef38c747c8801980f1d9423d040cf36220d76"
