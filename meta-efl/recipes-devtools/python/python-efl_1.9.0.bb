require ${BPN}.inc

SRC_URI[md5sum] = "c643d66157cac9b2892af8b6d1a803b1"
SRC_URI[sha256sum] = "f6d6fecca20df016acc79a12348ae0a0f6db82e6cceaf53c4b46d7ca72bb8f07"
