require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-beta"

SRC_URI[md5sum] = "19262c0baac27f35f136e4aaa3ca0171"
SRC_URI[sha256sum] = "6784109dc637bd8a50f31eb3a9ff31e0eece0fba04c8a2a527d6bd83c1b02cf8"
