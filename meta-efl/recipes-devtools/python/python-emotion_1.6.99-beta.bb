require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-beta"

SRC_URI[md5sum] = "3cfd52e8415f48d77fdb1fe73244c2b2"
SRC_URI[sha256sum] = "76d673b99e5e894b469bb04f67a14492a6021edc95762ba71da7b24c36fa660a"
