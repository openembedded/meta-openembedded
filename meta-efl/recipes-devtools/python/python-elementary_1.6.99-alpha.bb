require ${BPN}.inc
PR = "${INC_PR}.0"
SRCVER = "1.7.0-alpha"

SRC_URI[md5sum] = "bad3bd52e79aeea1ee9ffa0ab8a54855"
SRC_URI[sha256sum] = "32ded2fb4e66aa543ae9274076d031f8465167a0cc1af3fcd26bcda85b2e7094"
