require ${BPN}.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ac7197ce2617a87fad3dd134a98ad01f"
SRC_URI[sha256sum] = "ac2910c0e3e861dfc07253b825dc038baa1a3e6ce7d5b362122ad51127e20e91"
