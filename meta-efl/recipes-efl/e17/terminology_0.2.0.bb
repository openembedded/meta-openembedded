require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "61301df6b068b84e1670c85b7696f28d"
SRC_URI[sha256sum] = "e300dba5f77af7949471c81251c38af765c337b86c8ae9b98ec1dd0d6efbc1c9"
