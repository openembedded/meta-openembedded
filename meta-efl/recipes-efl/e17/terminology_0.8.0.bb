require ${BPN}.inc

SRC_URI = "\
    ${E_RELEASES}/apps/${SRCNAME}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "9f664d3205deaad956c253081cebf9fb"
SRC_URI[sha256sum] = "7a10d44b023cf6134c2483304e4ad33bea6df0f11266aec482f54fa67a3ce628"
