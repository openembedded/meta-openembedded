require ${BPN}.inc

SRC_URI = "\
    ${E_RELEASES}/apps/${SRCNAME}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "e68d889f343886e11a8e4f4337486452"
SRC_URI[sha256sum] = "453f49911b090fffc1e5fe695022bd1c51325dde83b8cd3cca22899c604344f4"
