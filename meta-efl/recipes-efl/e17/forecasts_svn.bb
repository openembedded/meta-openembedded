LICENSE = "MIT"
PV = "0.2.0+svnr${SRCREV}"
PR = "${INC_PR}.0"

require e-module.inc




