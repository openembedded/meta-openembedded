require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "7cecd058cb4509873412252477f2ce5b"
SRC_URI[sha256sum] = "77850b1100fab93fc5c3c571d78f80fe10f5b153863dbb8efad83eccb55cc5b6"
