LICENSE = "MIT"
PV = "0.0.2+svnr${SRCREV}"
PR = "${INC_PR}.0"

require e-module.inc




