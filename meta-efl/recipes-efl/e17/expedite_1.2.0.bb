require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "e9dfdf3dc35fdbec189914e3960c9949"
SRC_URI[sha256sum] = "533b18a823c8e417bd3b04db8d4f3ad7dcb4596e14397e38dd1788d39d98fe3d"
