require ${BPN}.inc

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "c9d387243a1ffa9318a491315c7007c8"
SRC_URI[sha256sum] = "b02bcc17ba9f80a1a9df456ae95584b98747a2ff14f90c9c0471a16869bd35dc"
