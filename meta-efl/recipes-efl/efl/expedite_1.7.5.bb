require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "a4347a00dd765bee8c1562f101f28599"
SRC_URI[sha256sum] = "6e7d577c2a6589d9d7a8fe10c2d913996be2f3fbc21cc6372880815b1f0e45d6"
