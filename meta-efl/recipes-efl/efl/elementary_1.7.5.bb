require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "8c81926114f07d328aacb0e34c3830a4"
SRC_URI[sha256sum] = "2798763a125792f4cd28b01a68799c7d7d113d4df12da60a13954e68108c7566"
