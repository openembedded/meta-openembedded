require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "8aa82193b59aef8fc91577f1226d2daa"
SRC_URI[sha256sum] = "ad912d56b6f3e27442d069ce1c8f1ba50b635ef5f408a9cc00912c927bed2a1e"
