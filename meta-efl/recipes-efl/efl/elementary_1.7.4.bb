require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "cf2ca073656ebac36c26df4fa4debdee"
SRC_URI[sha256sum] = "92ffb1a12883cd7d599e428a28501e4ce411db9839c698bb4095c9a1a470dccb"
