require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "c8b4c39efed63bdf503d45c8a94557a6"
SRC_URI[sha256sum] = "e12146e7b6acca6a9f0fac5849a01ffcfa65004f7b1d5053cfb8c0e37d4dea98"
