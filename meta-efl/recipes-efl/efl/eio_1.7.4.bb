require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "f2e4b4e4c04e83bc9533ef7938b51218"
SRC_URI[sha256sum] = "5d1233d8bf2ab9d955ab0682b8fa1c15fe5905a543820c3255a16d1c49ec33c1"
