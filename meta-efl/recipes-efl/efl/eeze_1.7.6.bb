require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "8e23ead15f9f52df5ffd05560153756f"
SRC_URI[sha256sum] = "4fa401a67dcec4b711e3eb29d827a2453b77e9add91938a4e30de866d36155f4"
