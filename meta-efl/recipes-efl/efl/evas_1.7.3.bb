require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "2a5bab8f87569d770b4a95fc0a382be4"
SRC_URI[sha256sum] = "d47cb26a384e6d523aa18df4fd558d0415165322ba714b83d99799e8531c617b"
