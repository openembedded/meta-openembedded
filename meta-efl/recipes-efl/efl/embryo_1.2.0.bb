require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "6c070a16d61141d695397fc248e6176e"
SRC_URI[sha256sum] = "432838f5f02c86da785beff0a1e0210a1d3f28121bfb6d6c70300839df31a70c"
