require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "4b1c45fdcf0acb9744c55ba2a4f3b139"
SRC_URI[sha256sum] = "b357415be9bdcdc0dc396821cc2c08aab5bae1e6e67aeaeceb1201e9f7dcae25"
