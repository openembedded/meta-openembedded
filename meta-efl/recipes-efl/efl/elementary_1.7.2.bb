require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "589ae692eb8dbe73fa12b1587c8f877d"
SRC_URI[sha256sum] = "582dd348e7dfcf76d7ec7fcfc3d4f6f8a73b653ffecf6979121a3bce190f98cf"
