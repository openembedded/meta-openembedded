require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "f7bbf5dc5bc1212d3116c5452b4a3510"
SRC_URI[sha256sum] = "f8a4214e3d210396b267325268ba6fcc31a42634fab5bf2efcbc595dbfb2c25f"
