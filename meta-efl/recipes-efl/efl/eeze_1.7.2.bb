require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "4a5d466a00989fe03abd218608cd1d99"
SRC_URI[sha256sum] = "fbbf42665a2618a2ca7a8080c7a2617cad819b24b3cb3c4f54417aab67ddac97"
