require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "bd573ab01d678280d570cbac07ef1053"
SRC_URI[sha256sum] = "332bdc121677f1f3319beed59513e1e7ee9d0076bed8db53db428251cc52f2c0"
