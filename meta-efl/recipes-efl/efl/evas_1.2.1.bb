require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "830161bd790c2c5f17aa47e3a1c3abe1"
SRC_URI[sha256sum] = "a019b410dba86e616163bafb6524d8734ac8c97aab7c41409f5176f23944bae6"
