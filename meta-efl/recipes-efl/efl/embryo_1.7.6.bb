require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "6302e1845d50074a949d8d822e2c8874"
SRC_URI[sha256sum] = "0d0d584b031193f86ce0935898bc3dccb263e945f981125bc7804903c8d34a84"
