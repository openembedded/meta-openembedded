require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "f470cdfad747f615a25785ba18044ea6"
SRC_URI[sha256sum] = "674177824a0dd20c29caec20b94355bafa529d15243cc1a06fe6bec1cbe7d88b"
