require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "66f424e80b11a28e86de4b2b9828591d"
SRC_URI[sha256sum] = "66c871a877ead4131fea82bab60018ef721b911df3208961eb967d45342bf23a"
