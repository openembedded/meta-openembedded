require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "4f0075f404223284dac0f34f676c511e"
SRC_URI[sha256sum] = "f204c0de00f46c54bf923477797d75e8b48e00f9173143e0e057e98a2dda9427"
