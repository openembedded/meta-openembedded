require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "c5d34d35ee38ad7c68b9f477d036c659"
SRC_URI[sha256sum] = "e6270573104af01bf377755f3cc292a27171a74be7cbe8de889aa3b5e811c279"
