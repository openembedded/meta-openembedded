require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "e7d68ed52d1eafa0998e74fab9c22e97"
SRC_URI[sha256sum] = "60f0cdc627806256e81c685080b97a10f348a53f9198360ff1c67ca0547ed806"
