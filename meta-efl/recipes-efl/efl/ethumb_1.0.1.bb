require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "20bd55bfa05d0c20e985f1031a683677"
SRC_URI[sha256sum] = "67449d0521d3c806b57e4d8ea121089dcbdf4fbcc2fb451ae881bd05025f6715"
