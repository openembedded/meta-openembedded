require ${BPN}.inc

SRC_URI = "\
    ${E_RELEASES}/libs/${SRCNAME}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "895d8057fb5cdcadd9ed1f710a460b4e"
SRC_URI[sha256sum] = "d3221726df583b3d5d43192e4909c08ac4dbf7ff35b81568ac339d7dbaf84d36"
