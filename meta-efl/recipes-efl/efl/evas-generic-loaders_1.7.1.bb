require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "6867ad898fb9dd1caf4449add0014c74"
SRC_URI[sha256sum] = "352d0ae98f4b39c57afe6defb8ba1419f43b6ea7c79c9810cccad020f904117c"
