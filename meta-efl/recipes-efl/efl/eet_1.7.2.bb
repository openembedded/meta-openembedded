require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "fb3014a5227e466261a49eee5747597b"
SRC_URI[sha256sum] = "03693c282db583d1a224d0134a61a3a138ad99cfa329f9c220f585bf8a4677f8"
