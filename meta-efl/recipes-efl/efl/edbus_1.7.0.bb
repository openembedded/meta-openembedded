require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "3d59bfb00763a61976a976be925e1cbf"
SRC_URI[sha256sum] = "6ee303bd0e2f91a6be08433df474377494ba6815441e5e6b79a5d284ead2a768"
