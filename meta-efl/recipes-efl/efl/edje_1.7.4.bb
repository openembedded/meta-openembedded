require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "fcd3749e41041854503b578e690cc672"
SRC_URI[sha256sum] = "7b81f512bd7cabfbe787d2bfd2d6c622c9ce151684ee57017c1bb1616f5d0e51"
