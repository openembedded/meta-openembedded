require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "ca0278ccbf753de78d5847f8665ffcc1"
SRC_URI[sha256sum] = "0356212b4f64ddc2397d6fb67195bd937248cd82f7f80b248e58d1e709289c8d"
