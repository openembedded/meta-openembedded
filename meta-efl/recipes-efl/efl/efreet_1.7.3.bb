require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "64a279b4568a769f657b9c9820a0bf74"
SRC_URI[sha256sum] = "bc337d6c2cf80358d25e885c3c3dd3098cbedf1b5e4ef8d2acab41b4870648df"
