require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "20de3518260eeeed14f54e8d013e23c9"
SRC_URI[sha256sum] = "fd512821f581b6d16998bac19e479ecf5a191940ba0e0b0a1250f6b04636d08c"
