require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "698c1b09d4f380ac581a6100f5b88548"
SRC_URI[sha256sum] = "3bd2796f11f33c2b0a2078694b2e4805b44d03f971f1e78c8da99944ae7e7af0"
