require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "5dc2712b71f202d32c07394ad253a071"
SRC_URI[sha256sum] = "013ee257f4be3acfb94ef3f2e5b06aedd48ed528e66833fb5e3ca71479912bea"
