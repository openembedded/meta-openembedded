require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "64c441dffeb9eb6ee7ad68ee9501506c"
SRC_URI[sha256sum] = "4e9511b736b80b0495ae0a54c9638615ee5336f57a9874f4fb16f11c0b8f563f"
