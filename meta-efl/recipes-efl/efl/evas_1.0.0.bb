require evas.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "8bcea881d472d526367f5280df4060a2"
SRC_URI[sha256sum] = "129d460f314fec43b2c5aad6c5f81e2797bca5e255f4b333b3d0b7b9ef81c4b0"
