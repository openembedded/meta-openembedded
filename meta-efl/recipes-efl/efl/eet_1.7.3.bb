require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "6befcd8b1c12a44ff2c2c91bbbbe001b"
SRC_URI[sha256sum] = "24c4f2fa8a186aa5e1a810beb58e03c806e26652f58aded6b1148c4cf44e98b3"
