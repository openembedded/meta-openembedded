require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "eb15b6faa1e4a30f80622a1381c670fc"
SRC_URI[sha256sum] = "7507a2544fb9d59e8a8835628a44141943bf3a7489f093eb557be396c3eff650"
