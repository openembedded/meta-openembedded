require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "485b6f47bffa9e44db4aa9cf60e3bcb5"
SRC_URI[sha256sum] = "6d162b9b401aa4f7f3387edce7cd488c33e71633091b0cc1e9540471bb400de0"
