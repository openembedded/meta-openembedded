require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "079cce349333b4831d3f56abeefa1d2d"
SRC_URI[sha256sum] = "b7850d1f1438ba58b780320d37522bf2e9e81339ebc6b660ad9cb3ea81f6c253"
