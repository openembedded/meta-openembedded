require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "edbbe1cfd6f73de3af74b83c980ba0c8"
SRC_URI[sha256sum] = "5bf904a6c6e79e2046d0b3f355570f754511436636d41a271aeed6890cb25194"
