require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "a4a2aa43a41afa783132a7220c450f6b"
SRC_URI[sha256sum] = "0b5f0c7f2357f0e31b9cf797e5a606bd491d75c9f3b8e006da15d4a8c17c9225"
