require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "aa1f96d4166edc154e773210e8ac8d21"
SRC_URI[sha256sum] = "93f5f00127176701b946d0db941d5209c5ca13659e184a31c0883ac1e145ce5d"
