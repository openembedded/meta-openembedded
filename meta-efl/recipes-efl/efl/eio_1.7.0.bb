require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "02e734ade8de360ef85835c5f5a1f2fa"
SRC_URI[sha256sum] = "c55ae0a8c303873b85b3b538662e85748154ea0434867291d481ac983c8d962c"
