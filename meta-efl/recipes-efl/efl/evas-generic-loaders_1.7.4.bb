require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "2edde882521b30a4cc3ce092a1ef86d0"
SRC_URI[sha256sum] = "900404a946f7169efe3c21e9960225dd2277e14ac0e75e597160861bd41b632e"
