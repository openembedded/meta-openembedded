require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "493208b3d3e1f3626b65a3257c1ff0ed"
SRC_URI[sha256sum] = "e0e96388c6a0a2a36ae1a38b6e36f5c27f7ad310fb213bd9c795b98678f99a69"
