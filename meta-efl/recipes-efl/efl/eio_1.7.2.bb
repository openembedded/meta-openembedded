require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "b8e3b115a63f423a70ce7459c0b77d58"
SRC_URI[sha256sum] = "c4af1062c27d2e0fef6d6919df39921c832553ff448628a5d9fe3704186a714b"
