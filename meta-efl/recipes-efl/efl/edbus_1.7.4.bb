require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "eaae06263de72944c0e818205c555b8b"
SRC_URI[sha256sum] = "17a63299957f80c2f9d13945dab2b28933f3eda7a7a2c0fff17dcc6cc5dc83a4"
