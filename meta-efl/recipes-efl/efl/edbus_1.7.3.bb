require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "c1eaa663812a04dcd5bdf3ea952f19d6"
SRC_URI[sha256sum] = "f893304271b1b233933cb66ed03810d02bc47794f8c23119f656304632d6b7c9"
