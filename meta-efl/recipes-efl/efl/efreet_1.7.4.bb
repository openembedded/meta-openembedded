require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "439cb27888cc1e6bf6ec5bd23512df7e"
SRC_URI[sha256sum] = "30c757294d662ef618227fb7fb02a0f73a781f0d31bcb393970b6c7a931729e0"
