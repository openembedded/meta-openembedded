require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "d9bf302b9b3f6cfd98840e6e8ca8c0ce"
SRC_URI[sha256sum] = "ad2b545d29920a3c245e7d73cced8be0fbef28cc003028fe4938961810748fef"
