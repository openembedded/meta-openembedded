require embryo.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "2d6269c931656d5714197e508b144f18"
SRC_URI[sha256sum] = "7d6fa883479262776e74c2b5506e72eebfe5826341eba0da1609e981f4dd0932"
