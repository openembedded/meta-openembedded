require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "48f28d887432f9aca434c864de33d5f8"
SRC_URI[sha256sum] = "eb52844e6bb95df1b83397fbcc3c7e234631cd91c83271781320f285eaf75d44"
