require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "3728318ac1a90980a608e4a1780d5d98"
SRC_URI[sha256sum] = "a70d2a3404c08a85a733111a90fae2fa7a3411478907963ade7f0f10216bb51c"
