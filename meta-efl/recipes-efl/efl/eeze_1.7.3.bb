require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "4ccc70135b1221a532206fb53c84e434"
SRC_URI[sha256sum] = "22a47e477609dda00e8360f05648367c320289a7132cc2f012e830632da92c6b"
