require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "a4ee8343fdb93ff00359e595f45488cd"
SRC_URI[sha256sum] = "d3c801995d7ec1f85de0adda440c4577060e2895c4ef21da60077773d5874f1b"
