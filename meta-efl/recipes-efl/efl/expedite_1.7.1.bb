require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "ee55884946e0c8e372938d3731ac0dca"
SRC_URI[sha256sum] = "1399d72d4bef1e1873b97987c81613271dfd03942b03769bada503166d036b18"
