require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "8050f8701e3176a9f880ed50bbfd33a6"
SRC_URI[sha256sum] = "975461750b6487884bd39dbd1078cd2a1a333451a8b85c8d6bb231d87936caf4"
