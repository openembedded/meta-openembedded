require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "00669561a82bad4df4a6268f1957ae40"
SRC_URI[sha256sum] = "94e312367a8d04a7d69627e5a3bb1eb4bd8de9d165c0288400527808ef43f956"
