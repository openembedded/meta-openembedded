require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "a4a6f3a84ff85d78c74e56a046bd3419"
SRC_URI[sha256sum] = "d4f739779c45dcc1ff221fb17100f9928309bbf5ea243b4da6554c08025b2c18"
