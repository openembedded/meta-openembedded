require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "0af7e3a5e0bf931bf87294d39eae3623"
SRC_URI[sha256sum] = "4eef549641d26b921f564169af1f21f7854431f523897cd167d3c3c860e854aa"
