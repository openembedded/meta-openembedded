require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "77237b48c4167d30b40b7918eb8e274f"
SRC_URI[sha256sum] = "a5de7921dadc8ed5726a16aca18fba48b43348556fde5b9454ef9b3468a21c6a"
