require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "29e40bb99bb05e4ebe91f3dc2796e12f"
SRC_URI[sha256sum] = "bc01384a69b138e6aae669b17bfaf3f34ac6189dc5b2e909917098b582d41749"
