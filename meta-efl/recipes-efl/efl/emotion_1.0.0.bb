require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "dc1e981c05318d2c3373acfd1cb18079"
SRC_URI[sha256sum] = "faa1fbd30a297fdb06b8545ffb6d0d961de850f012dc1a8b3033d1800fac3a78"
