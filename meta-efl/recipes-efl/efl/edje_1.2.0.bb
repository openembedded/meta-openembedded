require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "a1f848b842e049a789833f9d46ee8a8e"
SRC_URI[sha256sum] = "0e411679a4d2710f6e3933bff4fda3966fd6140eef89b3d96d663d5f38878290"
