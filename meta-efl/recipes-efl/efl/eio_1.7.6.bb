require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "c180817c536822153a1853b74a96d01a"
SRC_URI[sha256sum] = "659db01da170a7c02b9087b0b66c238ac834016973fa04b13575b1bc445d1c00"
