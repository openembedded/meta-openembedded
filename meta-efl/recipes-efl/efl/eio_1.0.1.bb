require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "a079913877d79417bc06dfecbf57c949"
SRC_URI[sha256sum] = "8a7079bf1e980e0d00fa9656e641e4a8a5aabf66986e76dcf06882ccf9623ed0"
