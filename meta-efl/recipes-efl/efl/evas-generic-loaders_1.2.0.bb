require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "340a8c2f42c82ecd10f0204cdb291a70"
SRC_URI[sha256sum] = "9a3aad43269f34513765b04ed3e8db5a18d3545da010b2f6066aeaf90bf442d4"
