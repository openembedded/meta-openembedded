require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "4e44e192701fa01a944a612a71d0e4ac"
SRC_URI[sha256sum] = "b55ab73a943b91adad455899390979a2bcabc15e4bcc6e523f1d79398eb01957"
