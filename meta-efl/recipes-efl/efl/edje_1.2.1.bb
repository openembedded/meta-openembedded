require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "b9df053b327cb41d2de2485bd596bb44"
SRC_URI[sha256sum] = "b793e98e9f65dfe7d007563e9d4cba84807a4473dfa9c94cdaee1ed9752cf6e0"
