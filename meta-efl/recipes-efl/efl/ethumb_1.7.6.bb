require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "343ef0dfda62295db353b7dca059e4a7"
SRC_URI[sha256sum] = "c93bdfc9cf10f8759c41c172167cb1b5ebccddd8f499cc7e1bcc5410cae3146a"
