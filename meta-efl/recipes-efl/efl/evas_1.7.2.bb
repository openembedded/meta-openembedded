require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "4e412c79609ae107968c9c45c4b900c0"
SRC_URI[sha256sum] = "2076608e6a9ac3331b17357c152b640ea0f3eccad24a9c270ad325d5434ab811"
