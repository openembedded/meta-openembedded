require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "20fc8b8d364f518adf6d92c2e31650f9"
SRC_URI[sha256sum] = "cc23bfc65528e3bc7ba078db739653d95bd9b255d565b09745a161d338d699e4"
