require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "8b53d2d945d6a40b012472f47568879a"
SRC_URI[sha256sum] = "aab476f80d4ad89056ba3860dfbb681c335c3688825fd587f5cbc6d9728abd41"
