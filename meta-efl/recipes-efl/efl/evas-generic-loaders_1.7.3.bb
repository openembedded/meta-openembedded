require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "e188843ccf4cdcf31f9645fdd28c9567"
SRC_URI[sha256sum] = "98bf7896535ca9d454bbc5b84b59c619a4b0ac80fadd067a102d20f1a9ea5db0"
