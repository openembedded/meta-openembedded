require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "6997f0fad5b041b9c1df25a2cd98bc24"
SRC_URI[sha256sum] = "c543031073f267f637cad2eaa51cd1ccdeab98f45f2a1eb438c4c49aebfd53b7"
