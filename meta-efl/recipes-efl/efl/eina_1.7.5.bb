require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "ca45a53ec219c8a16631a20dc0f782cf"
SRC_URI[sha256sum] = "294f2ee7c63a03ad84072d7f5b1aa7bc974afbb95e30748387bd812e20dc1952"
