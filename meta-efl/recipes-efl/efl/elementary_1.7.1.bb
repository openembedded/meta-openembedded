require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "938cf8de6012d2de8db7971f6874feac"
SRC_URI[sha256sum] = "619074b1561212e8fdb0c0f05a2204ba3f9a3fdebd51ad53adabf5a7d62d3712"
