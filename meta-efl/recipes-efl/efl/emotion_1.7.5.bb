require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "bb6a00053b0f72c0c146a59161e4bb0b"
SRC_URI[sha256sum] = "7d99fdd5c944a4df5ee635a4f4ca774f5887b02689de62fa4dabdf4bf76ec813"
