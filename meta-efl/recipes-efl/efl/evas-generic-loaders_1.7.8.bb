require ${BPN}.inc

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "8d6c7f56db854fdf931fc9270d0fda87"
SRC_URI[sha256sum] = "4f5f2a00eb065049de3e31cd86aee7de3b0593b9aec70aeb851f4f8189233d34"
