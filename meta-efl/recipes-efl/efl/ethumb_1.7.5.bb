require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "6c9fde046edfed867de790a8cd3a16f9"
SRC_URI[sha256sum] = "decb90a98ef94b1f52150c5e55e87c736824e24b01316486e9954760daac4cf5"
