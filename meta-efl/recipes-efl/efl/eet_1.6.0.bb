require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "4fb2c27bdfe4c2f56f42e5da0c518a2f"
SRC_URI[sha256sum] = "f14872b26f0857aed18e184d5080da7ac994fa35ddc209e23be447dcc2fdbd50"
