require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "3b4694a1b7c8f635effb225fe4c1f43d"
SRC_URI[sha256sum] = "9064d4b16882d3657caacf9fe9a93849e71a93c9fdc6bbc20901ff89c9296e06"
