require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "e5f60ff5a227abd6121c6749000aa0f7"
SRC_URI[sha256sum] = "baff603d614da0b52d505544f18c670e7dfd700e0c1df5ea56284ba3d737c7ee"
