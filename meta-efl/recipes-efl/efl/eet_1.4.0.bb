require eet.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "5b0f3034d2dcc2ad13049a4ab6100ca6"
SRC_URI[sha256sum] = "0355656d938b4086b42d65ceb6eb6f1637d990231f10707be968730b592f0bc3"
