require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "402e1da5f5281607585c860012200b49"
SRC_URI[sha256sum] = "5af9e0111ff519aa63adba48c91150ae4d6eb5697ec5fd8ad20016a7ed44f1ea"
