require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "33f8de3b590269b7dbe6960a0337b30f"
SRC_URI[sha256sum] = "6dcdf94224903c17ac753a388e6a2d0c23ce525859db93f022c3cd2b8f9afe72"
