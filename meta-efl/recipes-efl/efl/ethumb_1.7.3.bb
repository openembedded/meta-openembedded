require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "7394c4776a980490aea0bea5e35f05a4"
SRC_URI[sha256sum] = "25090565d995029a4fb57ac82ded1470b1beb8c23eeadaf713a30ca0cf58bb29"
