require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "8412b682a0445621edd7f23af0a0347e"
SRC_URI[sha256sum] = "c50005246219668f2d7f0e00f4632c7e20f5eddb73d2de18c66d1a729dc569af"
