require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "429c30b99f4011b7b20085f7117a7b93"
SRC_URI[sha256sum] = "e5b0c72fe9f6ea9db5c3c6966338fe718cf53c4a4b7d9b7a900a20e7341cf05a"
