require ${BPN}.inc

SRC_URI = "\
    ${E_RELEASES}/libs/${SRCNAME}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "b7c57c082e6b431ffeabe3803c6546b6"
SRC_URI[sha256sum] = "c6e729270c1ee79a8785388568eef394a6ba2cbe264c5c7d6c747727e8d9e60e"
