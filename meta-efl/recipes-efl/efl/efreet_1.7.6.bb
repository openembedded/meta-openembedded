require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "3888d88fcbf50e8977fc9f198facee8e"
SRC_URI[sha256sum] = "499b9c29016b10efd9b2c6c784b8413986269db8313fa95fb39dd2e042cde5bb"
