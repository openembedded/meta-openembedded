require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "eacc4e3a3534965469136a2e7cdd076b"
SRC_URI[sha256sum] = "3a7388225ce97432e4324f5c2da4d4aaa3e711b8a6e92021b4edd47fbed5099a"
