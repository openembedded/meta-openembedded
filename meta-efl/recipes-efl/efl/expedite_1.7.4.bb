require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "bf8d20bc35b28ff5696781eac4685681"
SRC_URI[sha256sum] = "3fdb6d56ac5de4ea40ad00f0d3a2b8dc3018be29f9ddb148ec3cd1ed5006e50a"
