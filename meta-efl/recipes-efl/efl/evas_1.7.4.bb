require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "33a70651fd3d73c3d928b9c5362d5aac"
SRC_URI[sha256sum] = "a3e19a0bbad3cfafc314c46baa0b5250382809bc04e458bd0c02b5ce68a29da6"
