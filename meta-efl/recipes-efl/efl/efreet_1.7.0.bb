require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "f039197e14288ecef94eeab040cbbdb4"
SRC_URI[sha256sum] = "16a41a03d55febf30f2dd786b51be3e370fc563f3335dd26832e0eaa88516c79"
