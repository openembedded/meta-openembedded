require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "db259be6c9468df32887a5480f666498"
SRC_URI[sha256sum] = "3f817154f2fdf6768abb94fd739e8f677d3a2070ac642812df955f0a9c46f5c7"
