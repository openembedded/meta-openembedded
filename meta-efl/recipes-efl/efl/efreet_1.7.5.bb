require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "2df171ff22e88fda47bc916665b903ce"
SRC_URI[sha256sum] = "1aa48f7ae2f367e8c9cd8407d6a55b941b54df78e629163b7a4dab2d423f49bc"
