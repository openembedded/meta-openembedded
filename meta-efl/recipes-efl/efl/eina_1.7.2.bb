require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "5d0453d6e7eb6f2c1b4e40b8c5be6f20"
SRC_URI[sha256sum] = "caa1be5cdf3ed450472d4fa114983762bf40699adff506e6b493e4e37c842018"
