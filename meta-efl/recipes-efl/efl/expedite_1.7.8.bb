require ${BPN}.inc

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "378d4abb513fd4ae1d2e2f75a2d970e4"
SRC_URI[sha256sum] = "ac80d3f13af4f644e048a1fcb71fd5f12fdef7c11c19fe61c868273bf3f4deb9"
