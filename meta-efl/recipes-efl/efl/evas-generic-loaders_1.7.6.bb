require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "f025e08a673ba4f11a3d17fc50e0abb1"
SRC_URI[sha256sum] = "9cedd062da2305caa17d3ca8589efd640526d4b720cce89a177374c4e0fdf423"
