require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "58a1e8476dcc15ecffc8d542be656cb9"
SRC_URI[sha256sum] = "541d07017f99b567976b2678466dbb5b540a4e93bf4fab987f3d0d612010da20"
