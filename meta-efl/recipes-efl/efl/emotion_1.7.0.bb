require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "757f46039cd301d10ba2b9a637e9b2e1"
SRC_URI[sha256sum] = "6e35baa399135dacd41d5cad21cb23338e6331e926107c3e7bdc33b0da18c22b"
