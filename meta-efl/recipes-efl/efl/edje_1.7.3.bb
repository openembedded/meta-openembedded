require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "b1901b4d98d1646b45ff27dfd9ff8b7c"
SRC_URI[sha256sum] = "752c60f843b649d3bdfa51e78c13696ac1cd46374a8dbfe96c07cc7aba5381fb"
