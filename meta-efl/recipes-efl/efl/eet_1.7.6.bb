require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "16a3b3cffbc7d63a5efdd673793e4a7a"
SRC_URI[sha256sum] = "fbdebf7a07ba5b3c0821bd0941e048c411af2e6da2581ed57b806b3f7abb0748"
