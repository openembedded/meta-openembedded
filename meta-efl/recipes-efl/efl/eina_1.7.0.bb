require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "303b81bbfff684eef0e5be70ba977012"
SRC_URI[sha256sum] = "6aacededb08aa1090a1beecbf62acf3e2ce0676ac87d21c787c07983f801166f"
