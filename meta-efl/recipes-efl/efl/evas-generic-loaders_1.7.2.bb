require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "991f0ce50e203419f54cb148fb949bb9"
SRC_URI[sha256sum] = "0ca06936cfe308593c36eb80ac80ad229f2bc3bdc9270b75f96e09595194caae"
