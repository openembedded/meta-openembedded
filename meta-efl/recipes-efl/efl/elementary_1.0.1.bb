require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "df978462103b1b6a5af374ea22296d80"
SRC_URI[sha256sum] = "24af1521fee4a18e1039a908e5f9aefa2f767854c5075d06bb5d268cfde1e2be"
