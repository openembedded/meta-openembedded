require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "e00a876a607cf6a99c5fc768d2fb69de"
SRC_URI[sha256sum] = "a280b499a51b531a19c368c1f394b27dda4f6c1f5a0edd8f29036169a9402cef"
