require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "e523232dee5c88cda21ec2a3495d7f18"
SRC_URI[sha256sum] = "b5c67b0bcadadd59d5611652260b97af57b6b5a6890ebca1839d953dff22c862"
