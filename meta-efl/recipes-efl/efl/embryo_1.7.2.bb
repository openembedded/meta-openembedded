require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "4dd84e5c7f515b707e4d0fac92b60cc8"
SRC_URI[sha256sum] = "48e068da62f3bcad7fcf0dad6715f5a0c1cc75ae05529cc39679aeb7560d6803"
