require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "6bed064cc88b060e79e9418c557eac8c"
SRC_URI[sha256sum] = "e8f95696c87731b26a199990f190476acd94da103c6538f76ade30abd0db850d"
