require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "9ca60516294fcbd9c919c56e3bb19568"
SRC_URI[sha256sum] = "08967f5414614b062fae21b012680fcd6ce6c456521bb186593309451e2ff913"
