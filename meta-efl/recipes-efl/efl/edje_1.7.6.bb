require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "2fa9079a1c53efebad47dccf6cb3a62c"
SRC_URI[sha256sum] = "36663e1db7f615675b188f579454ef881fa7db1a3e8070ccedcb65dfedd0a959"
