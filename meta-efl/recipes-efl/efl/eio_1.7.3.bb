require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "968f7672eb6ee96e4bdd2bbfe55e5e8a"
SRC_URI[sha256sum] = "f63c02f04edc6c53e29b41488ca3749a8cae5bed76803d60ad80be4ca117c635"
