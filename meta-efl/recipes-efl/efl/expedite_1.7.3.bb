require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "e13456be6c8c6276baeefa2b91d14e7b"
SRC_URI[sha256sum] = "4b9ec22d25d5847998cd9a60ba2edd47e5e217183e661e60b8440252c62f916f"
