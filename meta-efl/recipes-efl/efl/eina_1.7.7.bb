require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "baeb29327fc017e3ced890dc822c74ef"
SRC_URI[sha256sum] = "9812ea4c98ad4086bb93dedf04f49125c41cf3c72773f7e2a89a2e3ea62cbce4"
