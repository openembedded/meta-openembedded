require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "f46bb8ab1699cd7acb8463e50a3ffb4b"
SRC_URI[sha256sum] = "290b452e6cb87f64b11b529c7f67c40192f87a73cc4c5be93a95f17b76f65063"
