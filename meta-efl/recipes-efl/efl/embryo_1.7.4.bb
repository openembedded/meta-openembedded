require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "f4e3350587108bfe9719b496689dccc9"
SRC_URI[sha256sum] = "300fe9750a2affebc6b3f94356dbc719d01a34054b2c7fc81a49f3e38a7ca975"
