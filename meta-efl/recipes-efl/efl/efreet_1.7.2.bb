require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "7490ccdb57d298e6226b4f5cb956c5c5"
SRC_URI[sha256sum] = "ebb8175664f9c486bd112a4915bda794ef0ecc68833bb6726cd76a395e64ab94"
