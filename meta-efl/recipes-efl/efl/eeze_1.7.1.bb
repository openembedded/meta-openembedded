require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "3da7e14b6736528285551a7fc3e18b67"
SRC_URI[sha256sum] = "42092b5be0857bba4c1de35fcf9d4ec159c14ef8f57582964e060520ea728b70"
