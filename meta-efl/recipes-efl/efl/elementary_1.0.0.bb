require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "c5bd504b03b6de0a4ffe28fa6a6233ae"
SRC_URI[sha256sum] = "897fff5f6e81e8b01670d5f4b253141b333679d56bab89dc8a7c3f857763f94e"
