require edje.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "14c33c2b9d1bd36d8507d55597c77991"
SRC_URI[sha256sum] = "6dace9249cccb488170e1a17ce9f1a00d160281d4a6512b482f6dd27327e6235"
