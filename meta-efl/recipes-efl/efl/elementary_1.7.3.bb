require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "2075fbbe8523027a3659ad08bfcf5a02"
SRC_URI[sha256sum] = "043375ba63fa8619e053e9014566fc72f22522ef48daedcdfc62dfc1f3eb0a22"
