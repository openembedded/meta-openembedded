require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "52abbd8ab0d55480166bf5ec49c78627"
SRC_URI[sha256sum] = "33901b9aa6b83f3c0a1ff044c7ffbb0773e46c12cc3e71ed63619fc1fcd9c29e"
