require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "4ccd99ad21e25bd651c8ca7a2d20f7f3"
SRC_URI[sha256sum] = "b4f7d101e957d69b14d1c9207df8d2c9aafcc4a8a0ddea7883c393ef4389249f"
