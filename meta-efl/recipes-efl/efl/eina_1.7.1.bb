require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "644b7e8a3c3a48238f2c4003c90925de"
SRC_URI[sha256sum] = "2dbaa926f758d7d2e8ff9d9efffbf0aceb5225b17fd2b464ce0fe279830098f8"
