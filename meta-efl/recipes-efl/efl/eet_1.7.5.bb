require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "c62ba7a771d16df9afe6e5869370e082"
SRC_URI[sha256sum] = "2012a49b1acea2cd33d0cd8086615ceb4f881f868817bfdef88d3a0a837a1e0b"
