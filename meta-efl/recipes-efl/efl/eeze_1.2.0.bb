require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "4a5a12514e8c2de5d88d31bf4c34cac4"
SRC_URI[sha256sum] = "4df8ace51385ab15932c856b121b14fb93f2f5a87a08004078fdff5fee451cec"
