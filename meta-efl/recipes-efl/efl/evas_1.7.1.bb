require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "bee3c29a5872a2489142806690e1c44d"
SRC_URI[sha256sum] = "bb8298d9f010172c7b4e60f9e07e3f8fce73d9cce49fd5b05232e40523c9606f"
