require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "46c6c6b21910b97caa62da57a0cd4b83"
SRC_URI[sha256sum] = "62f1caba9715ce9d4047fa9a2c4ed6c756cc37fc0078404b7074d16b9293c333"
