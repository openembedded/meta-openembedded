require eina.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${PV}.tar.gz \
"

SRC_URI[md5sum] = "207b64a6549642392c4a0760df78df59"
SRC_URI[sha256sum] = "75e0795e0cb27e6278441b09e5299ee4e8fbacaf2a1d7a4a2b86a82f059b520b"
