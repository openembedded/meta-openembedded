require ${BPN}.inc

PR = "${INC_PR}.0"

SRC_URI = "\
  ${E_MIRROR}/${SRCNAME}-${SRCVER}.tar.gz \
"

SRC_URI[md5sum] = "ca3b3d7263756ab3456e559e36f190a0"
SRC_URI[sha256sum] = "b3f19f79a3dbcfce25f939eaf4f65b9ab734d32e6af6a008293aee50a16ba53d"
