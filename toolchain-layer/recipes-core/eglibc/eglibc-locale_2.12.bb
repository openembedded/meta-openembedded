require recipes-core/eglibc/eglibc-locale.inc
