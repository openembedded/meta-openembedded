require recipes-devtools/gcc/gcc-4_6-branch-linaro-backports.inc
require recipes-devtools/gcc/gcc-common-4.6.inc
SRC_URI += "${GCC-4_6-BRANCH-LINARO-BACKPORTS}"
