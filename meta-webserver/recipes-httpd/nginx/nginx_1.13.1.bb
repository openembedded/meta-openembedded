require nginx.inc

# 1.12.x branch is the current stable branch, the recommended default
# 1.13.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=903753de5f86a1ee0341fd2f9491b282"

SRC_URI[md5sum] = "5c2fe93447140b8b1a815a13bc89355b"
SRC_URI[sha256sum] = "a5856c72a6609a4dc68c88a7f3c33b79e6693343b62952e021e043fe347b6776"
