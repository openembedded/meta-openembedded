require nginx.inc

# 1.12.x branch is the current stable branch, the recommended default
# 1.13.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=903753de5f86a1ee0341fd2f9491b282"

SRC_URI[md5sum] = "1f8529568f825dfa4da4e99ba483678e"
SRC_URI[sha256sum] = "5b73f98004c302fb8e4a172abf046d9ce77739a82487e4873b39f9b0dcbb0d72"
