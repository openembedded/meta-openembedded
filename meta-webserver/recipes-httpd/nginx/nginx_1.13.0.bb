require nginx.inc

# 1.12.x branch is the current stable branch, the recommended default
# 1.13.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=903753de5f86a1ee0341fd2f9491b282"

SRC_URI[md5sum] = "0ff7057465d5622c5b1279e91b273e96"
SRC_URI[sha256sum] = "79f52ab6550f854e14439369808105b5780079769d7b8db3856be03c683605d7"
