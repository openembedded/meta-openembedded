require nginx.inc

# 1.10.x branch is the current stable branch, the recommended default
# 1.11.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=903753de5f86a1ee0341fd2f9491b282"

SRC_URI[md5sum] = "7aeca793819c2b8df134c0b1cfe98361"
SRC_URI[sha256sum] = "dc22b71f16b551705930544dc042f1ad1af2f9715f565187ec22c7a4b2625748"
