require nginx.inc

# 1.12.x branch is the current stable branch, the recommended default
# 1.13.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=903753de5f86a1ee0341fd2f9491b282"

SRC_URI[md5sum] = "f84d3f782c168bfdfb734700e51a929f"
SRC_URI[sha256sum] = "8512fc6f986a20af293b61f33b0e72f64a72ea5b1acbcc790c4c4e2d6f63f8f8"
