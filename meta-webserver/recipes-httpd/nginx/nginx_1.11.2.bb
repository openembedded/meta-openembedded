require nginx.inc

# 1.10.x branch is the current stable branch, the recommended default
# 1.9.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "9db11337a924a665ff68c1785bcf314e"
SRC_URI[sha256sum] = "a0327be3e647bdc4a1b3ef98946a8e8fbf258ce8da6bed9a94222b249ae2700a"
