require nginx.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "e8f5f4beed041e63eb97f9f4f55f3085"
SRC_URI[sha256sum] = "1045ac4987a396e2fa5d0011daf8987b612dd2f05181b67507da68cbe7d765c2"
