require nginx.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=903753de5f86a1ee0341fd2f9491b282"

SRC_URI[md5sum] = "995eb0a140455cf0cfc497e5bd7f94b3"
SRC_URI[sha256sum] = "b4222e26fdb620a8d3c3a3a8b955e08b713672e1bc5198d1e4f462308a795b30"
