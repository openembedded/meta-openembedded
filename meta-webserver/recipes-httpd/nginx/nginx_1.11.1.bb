require nginx.inc

# 1.10.x branch is the current stable branch, the recommended default
# 1.9.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "0f3900165b11c417854535f3538913cb"
SRC_URI[sha256sum] = "5d8dd0197e3ffeb427729c045382182fb28db8e045c635221b2e0e6722821ad0"
