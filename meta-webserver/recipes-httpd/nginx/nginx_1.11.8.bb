require nginx.inc

# 1.10.x branch is the current stable branch, the recommended default
# 1.11.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "8f68f49b6db510e567bba9e0c271a3ac"
SRC_URI[sha256sum] = "53aef3715d79015314c2dcb18f2b185a0c64368cc01b30bdf0737a215f666b34"
