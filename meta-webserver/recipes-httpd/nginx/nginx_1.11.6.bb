require nginx.inc

# 1.10.x branch is the current stable branch, the recommended default
# 1.11.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "4e29a07a7c74376fa032e5af0d1c5369"
SRC_URI[sha256sum] = "3153abbb518e2d9c032e1b127da3dc0028ad36cd4679e5f3be0b8afa33bc85bd"
