require nginx.inc

# 1.10.x branch is the current stable branch, the recommended default
# 1.11.x is the current mainline branches containing all new features
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "18275c1daa39c5fac12e56c34907d45b"
SRC_URI[sha256sum] = "4a667f40f9f3917069db1dea1f2d5baa612f1fa19378aadf71502e846a424610"
