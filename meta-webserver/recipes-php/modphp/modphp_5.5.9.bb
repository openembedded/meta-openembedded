include modphp5.inc

EXTRA_OECONF += "--disable-opcache"

SRC_URI[md5sum] = "c4a348a07b52f6e177d8fdc75fe507b1"
SRC_URI[sha256sum] = "9d1dea5195e2bcd928416130a6e19173d02bd36fb76c382522bf145c458fbed3"

