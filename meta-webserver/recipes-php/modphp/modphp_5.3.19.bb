include modphp5.inc
PR = "r1"

SRC_URI[md5sum] = "e1d2a3ec7849d4b3032bd1abf1916aa4"
SRC_URI[sha256sum] = "814ce55b950158c4ddadbcd0b2d7d8cb4b570de4a29b9db021020594e2469fd6"
