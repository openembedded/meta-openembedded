include modphp5.inc

SRC_URI[md5sum] = "cfdc044be2c582991a1fe0967898fa38"
SRC_URI[sha256sum] = "5450f3843bc651eb3fb00601f0cce1930aaaf65c7c966c02fe4a46f9c81be20a"
