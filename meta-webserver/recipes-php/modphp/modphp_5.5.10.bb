include modphp5.inc

EXTRA_OECONF += "--disable-opcache"

SRC_URI[md5sum] = "d608230c7890b6a0cc5b92e66e866226"
SRC_URI[sha256sum] = "bb34e61f8e6f56c612867bfe85d144d5045cd5e44497539bc126a4e8c6795419"

