include modphp5.inc

SRC_URI[md5sum] = "145ea5e845e910443ff1eddb3dbcf56a"
SRC_URI[sha256sum] = "2d2285da48ccd2db311b2608fdfafd18b363a9f7e3796d53dd53e5b6752a0136"
