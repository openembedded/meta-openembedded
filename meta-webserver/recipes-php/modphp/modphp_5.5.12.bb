include modphp5.inc

EXTRA_OECONF += "--disable-opcache"

SRC_URI[md5sum] = "943af92c2e67bba29429bdd9acf9cbd4"
SRC_URI[sha256sum] = "519ee29e28532782676f3d8e31a808ffbfee383e0279ccc8cbd2b12ed53c2335"

