include modphp5.inc

EXTRA_OECONF += "--disable-opcache"

SRC_URI[md5sum] = "caf7f4d86514a568fb3c8021b096a9f0"
SRC_URI[sha256sum] = "e72aaf1fa96eac0bff127bfc74c174d1de50cd3f66d7e0e1ee919674ab463bb7"

