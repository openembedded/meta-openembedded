include modphp5.inc

EXTRA_OECONF += "--disable-opcache"

SRC_URI[md5sum] = "5cb5f2ed9099299f8a4c952d59d93812"
SRC_URI[sha256sum] = "00f24226b12fee27e332383b6304f1b9ed3f4d9173dd728a68c5c3f5a59b8ba7"

