inherit gnomebase gtk-icon-cache gconf mime

EXTRA_OECONF += "--enable-introspection=no"
BBCLASSEXTEND += "native"
